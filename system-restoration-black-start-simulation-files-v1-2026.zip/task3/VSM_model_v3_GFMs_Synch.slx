simulink model "VSM_model_v3_GFMs_Synch"  (R2024b)
settings: Solver=ode23tb  StartTime=0.0  StopTime=Tend  FixedStep=T_s  RelTol=1e-3  EnableMultiTasking=on
PostLoadFcn:
  | Tcontrol=20e-6;
InitFcn:
  | Tcontrol=20e-6;
values from neighbouring files (symbols this model uses):
  C_4 = 0.1670*C_b    (= 1.00487241952e-06)    [VSM.m]    (also in VSM_CSIRO.m)
  C_6 = 0.2835*C_b    (= 1.70587623314e-06)    [VSM.m]    (also in VSM_CSIRO.m)
  C_8 = 0.2275*C_b    (= 1.36891302659e-06)    [VSM.m]    (also in VSM_CSIRO.m)
  C_dc = 0.008*(n)    (= 1.6)    [VSM.m]    (also in VSM_CSIRO.m)
  C_f = n*300*10^-6    (= 0.06)    [VSM.m]    (also in VSM_CSIRO.m)
  C_f_gfl = (n_gfl) * Cf_unit_gfl    (= 0.00350140874802)    [DER_param.m]
  D_p = (1/(m_p*w_b))    (= 101321.183642)    [VSM.m]    (also in VSM_CSIRO.m)
  droop_percentage = 5    [VSM.m]    (also in VSM_CSIRO.m = 1)
  I_b_dc = S_b/Vdc_n    [VSM.m]    (also in VSM_CSIRO.m)
  I_b_LV_peak = I_b_LV * sqrt(2)    [VSM.m]
  I_b_SG_peak = I_b_SG * sqrt(2)    [VSM.m]
  i_ll = -1.15*(S_b/Vdc_n)-i_loss_dc    [VSM.m]    (also in VSM_CSIRO.m)
  i_ul = 1.15*(S_b/Vdc_n)+i_loss_dc    [VSM.m]    (also in VSM_CSIRO.m)
  J = D_p*tau_f    (= 2026.42367285)    [VSM.m]    (also in VSM_CSIRO.m)
  k_dc = eta_1/(Vdc_n*m_p)    [VSM.m]    (also in VSM_CSIRO.m)
  K_p = (1/Vdc_n)    [VSM.m]    (also in VSM_CSIRO.m)
  K_r = 1/R_dc    [VSM.m]    (also in VSM_CSIRO.m)
  Kff_i = 1    [VSM.m]    (also in VSM_CSIRO.m)
  Kff_v = 1    [VSM.m]    (also in VSM_CSIRO.m)
  Ki_i = (1/n)*1.19    (= 0.00595)    [VSM.m]    (also in VSM_CSIRO.m)
  Ki_i_gfl = (1/n_gfl) * Ki_i_unit_gfl    (= 0.571198664289)    [DER_param.m]
  Ki_v = (n)*1.161022    (= 232.2044)    [VSM.m]    (also in VSM_CSIRO.m)
  ki_v_ac = 4*5.2500e-04    (= 0.0021)    [VSM.m]    (also in VSM_CSIRO.m)
  Kp_i = 0.738891    [VSM.m]    (also in VSM_CSIRO.m)
  Kp_i_gfl = (1/n_gfl) * Kp_i_unit_gfl    (= 0.00909090909091)    [DER_param.m]
  Kp_v = 0.52    [VSM.m]    (also in VSM_CSIRO.m)
  kp_v_ac = 0.001    [VSM.m]    (also in VSM_CSIRO.m)
  L1_f_gfl = (1/n_gfl) * L1_unit_gfl    (= 1.44686311902e-05)    [DER_param.m]
  L1_pu = 1*0.0186/m    (= 0.000186)    [VSM.m]    (also in VSM_CSIRO.m)
  L1_pu_gfl = 0.03    [DER_param.m]
  L2_f_gfl = (1/n_gfl) * L2_unit_gfl    (= 2.89372623803e-06)    [DER_param.m]
  L2_pu_gfl = 0.03    [DER_param.m]
  L_45 = L_lines(2)    [VSM.m]    (also in VSM_CSIRO.m)
  L_56 = L_lines(3)    [VSM.m]    (also in VSM_CSIRO.m)
  L_67 = L_lines(5)    [VSM.m]    (also in VSM_CSIRO.m)
  L_78 = L_lines(6)    [VSM.m]    (also in VSM_CSIRO.m)
  L_89 = L_lines(8)    [VSM.m]    (also in VSM_CSIRO.m)
  L_94 = L_lines(9)    [VSM.m]    (also in VSM_CSIRO.m)
  L_f = (1/n)*200*10^-6    (= 1e-06)    [VSM.m]    (also in VSM_CSIRO.m)
  Lg = (X_BY_R_gfl * Rg) / wn_gfl    [DER_param.m]    (also in initialcondition_gfm_Pooyan.m = X_BY_R*Rg/(wn); initialcondition_Pooyan.m = X_BY_R*Rg/(wn))
  n = 200    [VSM.m]    (also in VSM_CSIRO.m)
  Pgen_MW_gfl = 20    [DER_param.m]
  ps = base/3    (= 0.75)    [VSM.m]    (also in VSM_CSIRO.m)
  R1_f_gfl = (1/n_gfl) * R1_unit_gfl    (= 0.000909090909091)    [DER_param.m]
  R1_pu = 1*0.00734/m    (= 7.34e-05)    [VSM.m]    (also in VSM_CSIRO.m)
  R1_pu_gfl = 0.005    [DER_param.m]
  R2_f_gfl = (1/n_gfl) * R2_unit_gfl    (= 0.000181818181818)    [DER_param.m]
  R2_pu_gfl = 0.005    [DER_param.m]
  R_45 = R_lines(2)    [VSM.m]    (also in VSM_CSIRO.m)
  R_56 = R_lines(3)    [VSM.m]    (also in VSM_CSIRO.m)
  R_67 = R_lines(5)    [VSM.m]    (also in VSM_CSIRO.m)
  R_78 = R_lines(6)    [VSM.m]    (also in VSM_CSIRO.m)
  R_89 = R_lines(8)    [VSM.m]    (also in VSM_CSIRO.m)
  R_94 = R_lines(9)    [VSM.m]    (also in VSM_CSIRO.m)
  R_base_gfl = (3 * Vg_gfl^2) / (2 * Pn_gfl)    [DER_param.m]
  R_dc = (Vdc_n/(0.05*(S_b)/Vdc_n))    [VSM.m]    (also in VSM_CSIRO.m)
  R_f = 0.001/n    (= 5e-06)    [VSM.m]    (also in VSM_CSIRO.m)
  Rg = (3 * Vg_gfl^2) / (2 * SCR_gfl * sqrt(1 + X_BY_R_gfl^2) * Pn_gfl)    [DER_param.m]    (also in initialcondition_gfm_Pooyan.m = (3*Vg^2)/(2*SCR*sqrt(1+X_BY_R^2)*Pn); initialcondition_Pooyan.m = (3*Vg^2)/(2*SCR*sqrt(1+X_BY_R^2)*Pn))
  S_b = 100*(10^6)    (= 100000000)    [VSM.m]    (also in VSM_CSIRO.m)
  S_bt = S_b    (= 100000000)    [VSM.m]    (also in VSM_CSIRO.m)
  S_bt_gfl = S_b_gfl    (= 22000000)    [DER_param.m]
  T_en = T_load-0.5    (= 24.5)    [VSM.m]    (also in VSM_CSIRO.m = 44.5)
  T_s = 1e-4    (= 0.0001)    [VSM.m]    (also in VSM_CSIRO.m)
  tau_dc = 0.05    [VSM.m]    (also in VSM_CSIRO.m)
  tau_g = 5    [VSM.m]    (also in VSM_CSIRO.m)
  Tend = 90    [VSM.m]    (also in VSM_CSIRO.m = 50)
  ts_DER = 15    [DER_param.m]
  V1_rms = 1000    [VSM.m]    (also in VSM_CSIRO.m)
  V1_rms_gfl = 1000    [DER_param.m]
  V1_rms_tx1_gfl = 1000    [DER_param.m]
  V2_rms = 13800    [VSM.m]    (also in VSM_CSIRO.m)
  V2_rms_tx1_gfl = 13800    [DER_param.m]
  V_b = 230*(10^3)    (= 230000)    [VSM.m]    (also in VSM_CSIRO.m)
  V_m = sqrt(2/3)*V1_rms    [VSM.m]    (also in VSM_CSIRO.m)
  V_m_gfl = sqrt(2/3)*V1_rms_gfl    [DER_param.m]
  V_sg_p = sqrt(2/3)*V2_rms    [VSM.m]
  Vdc_n = 3*V_m    [VSM.m]    (also in VSM_CSIRO.m)
  Vdc_n_gfl = 2300    [DER_param.m]
  w_b = 2*pi*f_b    (= 314.159265359)    [VSM.m]    (also in VSM_CSIRO.m)
  w_b_gfl = 2*pi*f_b_gfl    (= 314.159265359)    [DER_param.m]
  w_f = 2*pi*5    (= 31.4159265359)    [VSM.m]    (also in VSM_CSIRO.m)
undefined symbols (not defined in the file or in its folder): D1, Delta, DiscIntNeverNeededParam, dspblkCoreblockFVToolHelper, gcbh, i_dc, magnitude
libraries: spsSeriesRLCBranchLib x82, spsabctodq0Lib x40, slpidlib x36, spsVoltageMeasurementLib x32, spsThreePhaseVIMeasurementLib x31, spsThreePhaseBreakerLib x26, spsGroundLib x22, spsCurrentMeasurementLib x20, spsPLL3phLib x14, spsThreePhaseTransformerTwoWindingsLib x14, simulink x13, spsThreePhaseSeriesRLCBranchLib x10
(part 10 of 10)

== matlab function VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem1/DER/Subsystem1/Subsystem2/MATLAB Function ==
function [id_ref, iq_ref] = calculate_current_refs(P_ref_MW, Q_ref_MVAr, v_d, v_q)
    % Convert inputs from MW/MVAr to Watts/VArs
    P_ref = P_ref_MW * 1e6;
    Q_ref = Q_ref_MVAr * 1e6;
    
    % Safeguard to prevent division by zero during faults/voltage dips
    vd_sq_vq_sq = max(v_d^2 + v_q^2, 1e-6);
    
    % General calculation (works even if PLL is slightly misaligned, v_q ~= 0)
    id_ref = (2/3) * (P_ref * v_d + Q_ref * v_q) / vd_sq_vq_sq;
    iq_ref = (2/3) * (P_ref * v_q - Q_ref * v_d) / vd_sq_vq_sq;
    
    % If PLL is perfectly aligned (v_q = 0), this mathematically reduces to:
    % id_ref = (2/3) * (P_ref / v_d)
    % iq_ref = -(2/3) * (Q_ref / v_d)
end

== matlab function VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem1/DER/Subsystem1/Subsystem2/MATLAB Function1 ==
function Q_ref_MVAr = v_var_droop(ud,uq)
% Volt-VAR Droop Controller Parameters (AEMO Compliant)
% The 0.93 Power Factor Rule
% Under NER S5.2.5.1, the Automatic Access Standard requires large generators to be capable of supplying or absorbing reactive power equal to 39.5% of their rated active power.

Pgen_MW_gfl = 20;                       % Target active power: 20 MW
ps_gfl = Pgen_MW_gfl;
V_mag = sqrt(ud^2 + uq^2); % measured
Q_max_MVAr = ps_gfl*0.395;                   % Maximum legal injection (0.93 PF)  39
Q_min_MVAr = -ps_gfl*0.395;  
V_m_gfl=326.6; % Maximum legal absorption (0.93 PF)

V_target_pu = 1.0;                      % Target grid voltage (1.0 pu)
droop_percent = 0.04;                   % 4% Voltage Droop setting

% Calculate the droop gain (Slope of the Volt-VAR curve)
K_q_droop = Q_max_MVAr / droop_percent;  % 197.5 MVAr per 1.0 pu voltage error

    % 1. Convert measured raw voltage to per-unit (pu)
    % V_base_peak is your 326.6 V phase-to-neutral peak base
    V_measured_pu = V_mag/ V_m_gfl;
    
    % 2. Calculate the voltage error
    V_error_pu = V_target_pu - V_measured_pu;
    
    % 3. Apply the Droop Gain to calculate requested Reactive Power
    Q_requested = V_error_pu * K_q_droop;
    
    % 4. Enforce the AEMO Hardware Limits (Saturation)
    if Q_requested > Q_max_MVAr
        Q_ref_MVAr = Q_max_MVAr;
    elseif Q_requested < Q_min_MVAr
        Q_ref_MVAr = Q_min_MVAr;
    else
        Q_ref_MVAr = Q_requested;
    end
    
end

== matlab function VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem1/MATLAB Function ==
function [P_W, Q_VAr] = calculate_true_power(Va, Vb, Vc, Ia, Ib, Ic)
    
    % 1. Convert Voltage to Alpha-Beta (Amplitude Invariant)
    Valpha = (2/3) * (Va - 0.5*Vb - 0.5*Vc);
    Vbeta  = (2/3) * (0 - (sqrt(3)/2)*Vb + (sqrt(3)/2)*Vc);
    
    % 2. Convert Current to Alpha-Beta (Amplitude Invariant)
    Ialpha = (2/3) * (Ia - 0.5*Ib - 0.5*Ic);
    Ibeta  = (2/3) * (0 - (sqrt(3)/2)*Ib + (sqrt(3)/2)*Ic);
    
    % 3. Calculate Instantaneous 3-Phase Active Power (Watts)
    P_W = (3/2) * (Valpha * Ialpha + Vbeta * Ibeta);
    
    % 4. Calculate Instantaneous 3-Phase Reactive Power (VAr)
    Q_VAr = (3/2) * (Vbeta * Ialpha - Valpha * Ibeta);
    
end

== matlab function VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem1/Subsystem6/Subsystem5/MATLAB Function ==
function [close_signal, delta_V, delta_theta, delta_w] = Sync_Check(V1, V2, theta1, theta2, w1, w2, t,ts_DER)
    % --- Configuration ---
    t_min = ts_DER+3;  % Time in seconds to start checking (e.g., 35s)
    
    % Thresholds for larger DER >1500 kva
    delta_V_limit = 0.03;       % 3% Voltage difference
    deg = 10; % 10 phase angle deviation
    delta_theta_limit = deg * (pi/180); % Phase angle limit
    delta_w_limit = 0.1;      % Frequency slip limit (approx 0.1 Hz)
    
    % --- Calculations ---
    delta_V = abs(V1 - V2);
    % Calculate shortest angle distance accounting for wrap-around
    delta_theta = abs(atan2(sin(theta1-theta2), cos(theta1-theta2))); 
    delta_w = abs(w1 - w2);
    
   % --- Logical Condition ---
    % Breaker will ONLY close if time has passed AND all physical limits are met
    if (t > t_min) && (delta_V < delta_V_limit) && (delta_theta < delta_theta_limit) && (delta_w < delta_w_limit)
        close_signal = 1; % Permit closure
    else
        close_signal = 0; % Block closure
    end
end

== matlab function VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem2/DER/Subsystem1/Subsystem2/DSOGI-PLL/Embedded
MATLAB Function27 ==
function [Vds,Vqs]= park(alpha,beta,As)
Vds=alpha*cos(As)+beta*sin(As);
Vqs=-alpha*sin(As)+beta*cos(As);
end

== matlab function VSM_model_v3_GFMs_Synch/GFM 2/VSM Control/MATLAB Function1 ==
function e = EMF(M_fi_f,theta,w)
e=w*M_fi_f*[sin(theta) sin(theta-(2*pi/3)) sin(theta-(4*pi/3))]';
end

== matlab function VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem2/DER/Subsystem1/Subsystem2/DSOGI-PLL/Embedded
MATLAB Function7 ==
function Am = mod(A)
Am= mod(A,2*pi);
end

== matlab function VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem2/DER/Subsystem1/Subsystem2/MATLAB Function ==
function [id_ref, iq_ref] = calculate_current_refs(P_ref_MW, Q_ref_MVAr, v_d, v_q)
    % Convert inputs from MW/MVAr to Watts/VArs
    P_ref = P_ref_MW * 1e6;
    Q_ref = Q_ref_MVAr * 1e6;
    
    % Safeguard to prevent division by zero during faults/voltage dips
    vd_sq_vq_sq = max(v_d^2 + v_q^2, 1e-6);
    
    % General calculation (works even if PLL is slightly misaligned, v_q ~= 0)
    id_ref = (2/3) * (P_ref * v_d + Q_ref * v_q) / vd_sq_vq_sq;
    iq_ref = (2/3) * (P_ref * v_q - Q_ref * v_d) / vd_sq_vq_sq;
    
    % If PLL is perfectly aligned (v_q = 0), this mathematically reduces to:
    % id_ref = (2/3) * (P_ref / v_d)
    % iq_ref = -(2/3) * (Q_ref / v_d)
end

== matlab function VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem2/DER/Subsystem1/Subsystem2/MATLAB Function1 ==
function Q_ref_MVAr = v_var_droop(ud,uq)
% Volt-VAR Droop Controller Parameters (AEMO Compliant)
% The 0.93 Power Factor Rule
% Under NER S5.2.5.1, the Automatic Access Standard requires large generators to be capable of supplying or absorbing reactive power equal to 39.5% of their rated active power.

Pgen_MW_gfl = 20;                       % Target active power: 20 MW
ps_gfl = Pgen_MW_gfl;
V_mag = sqrt(ud^2 + uq^2); % measured
Q_max_MVAr = ps_gfl*0.395;                   % Maximum legal injection (0.93 PF)  39
Q_min_MVAr = -ps_gfl*0.395;  
V_m_gfl=326.6; % Maximum legal absorption (0.93 PF)

V_target_pu = 1.0;                      % Target grid voltage (1.0 pu)
droop_percent = 0.04;                   % 4% Voltage Droop setting

% Calculate the droop gain (Slope of the Volt-VAR curve)
K_q_droop = Q_max_MVAr / droop_percent;  % 197.5 MVAr per 1.0 pu voltage error

    % 1. Convert measured raw voltage to per-unit (pu)
    % V_base_peak is your 326.6 V phase-to-neutral peak base
    V_measured_pu = V_mag/ V_m_gfl;
    
    % 2. Calculate the voltage error
    V_error_pu = V_target_pu - V_measured_pu;
    
    % 3. Apply the Droop Gain to calculate requested Reactive Power
    Q_requested = V_error_pu * K_q_droop;
    
    % 4. Enforce the AEMO Hardware Limits (Saturation)
    if Q_requested > Q_max_MVAr
        Q_ref_MVAr = Q_max_MVAr;
    elseif Q_requested < Q_min_MVAr
        Q_ref_MVAr = Q_min_MVAr;
    else
        Q_ref_MVAr = Q_requested;
    end
    
end

== matlab function VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem2/MATLAB Function ==
function [P_W, Q_VAr] = calculate_true_power(Va, Vb, Vc, Ia, Ib, Ic)
    
    % 1. Convert Voltage to Alpha-Beta (Amplitude Invariant)
    Valpha = (2/3) * (Va - 0.5*Vb - 0.5*Vc);
    Vbeta  = (2/3) * (0 - (sqrt(3)/2)*Vb + (sqrt(3)/2)*Vc);
    
    % 2. Convert Current to Alpha-Beta (Amplitude Invariant)
    Ialpha = (2/3) * (Ia - 0.5*Ib - 0.5*Ic);
    Ibeta  = (2/3) * (0 - (sqrt(3)/2)*Ib + (sqrt(3)/2)*Ic);
    
    % 3. Calculate Instantaneous 3-Phase Active Power (Watts)
    P_W = (3/2) * (Valpha * Ialpha + Vbeta * Ibeta);
    
    % 4. Calculate Instantaneous 3-Phase Reactive Power (VAr)
    Q_VAr = (3/2) * (Vbeta * Ialpha - Valpha * Ibeta);
    
end

== matlab function VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem2/Subsystem6/Subsystem5/MATLAB Function ==
function [close_signal, delta_V, delta_theta, delta_w] = Sync_Check(V1, V2, theta1, theta2, w1, w2, t,ts_DER)
    % --- Configuration ---
    t_min = ts_DER+3;  % Time in seconds to start checking (e.g., 35s)
    
    % Thresholds for larger DER >1500 kva
    delta_V_limit = 0.03;       % 3% Voltage difference
    deg = 10; % 10 phase angle deviation
    delta_theta_limit = deg * (pi/180); % Phase angle limit
    delta_w_limit = 0.1;      % Frequency slip limit (approx 0.1 Hz)
    
    % --- Calculations ---
    delta_V = abs(V1 - V2);
    % Calculate shortest angle distance accounting for wrap-around
    delta_theta = abs(atan2(sin(theta1-theta2), cos(theta1-theta2))); 
    delta_w = abs(w1 - w2);
    
   % --- Logical Condition ---
    % Breaker will ONLY close if time has passed AND all physical limits are met
    if (t > t_min) && (delta_V < delta_V_limit) && (delta_theta < delta_theta_limit) && (delta_w < delta_w_limit)
        close_signal = 1; % Permit closure
    else
        close_signal = 0; % Block closure
    end
end

== matlab function VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem3/DER/Subsystem1/Subsystem2/DSOGI-PLL/Embedded
MATLAB Function27 ==
function [Vds,Vqs]= park(alpha,beta,As)
Vds=alpha*cos(As)+beta*sin(As);
Vqs=-alpha*sin(As)+beta*cos(As);
end

== matlab function VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem8/MATLAB Function ==
function [P_W, Q_VAr] = calculate_true_power(Va, Vb, Vc, Ia, Ib, Ic)
    
    % 1. Convert Voltage to Alpha-Beta (Amplitude Invariant)
    Valpha = (2/3) * (Va - 0.5*Vb - 0.5*Vc);
    Vbeta  = (2/3) * (0 - (sqrt(3)/2)*Vb + (sqrt(3)/2)*Vc);
    
    % 2. Convert Current to Alpha-Beta (Amplitude Invariant)
    Ialpha = (2/3) * (Ia - 0.5*Ib - 0.5*Ic);
    Ibeta  = (2/3) * (0 - (sqrt(3)/2)*Ib + (sqrt(3)/2)*Ic);
    
    % 3. Calculate Instantaneous 3-Phase Active Power (Watts)
    P_W = (3/2) * (Valpha * Ialpha + Vbeta * Ibeta);
    
    % 4. Calculate Instantaneous 3-Phase Reactive Power (VAr)
    Q_VAr = (3/2) * (Vbeta * Ialpha - Valpha * Ibeta);
    
end

== matlab function VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem8/Subsystem6/Subsystem5/MATLAB Function ==
function [close_signal, delta_V, delta_theta, delta_w] = Sync_Check(V1, V2, theta1, theta2, w1, w2, t,ts_DER)
    % --- Configuration ---
    t_min = ts_DER+3;  % Time in seconds to start checking (e.g., 35s)
    
    % Thresholds for larger DER >1500 kva
    delta_V_limit = 0.03;       % 3% Voltage difference
    deg = 10; % 10 phase angle deviation
    delta_theta_limit = deg * (pi/180); % Phase angle limit
    delta_w_limit = 0.1;      % Frequency slip limit (approx 0.1 Hz)
    
    % --- Calculations ---
    delta_V = abs(V1 - V2);
    % Calculate shortest angle distance accounting for wrap-around
    delta_theta = abs(atan2(sin(theta1-theta2), cos(theta1-theta2))); 
    delta_w = abs(w1 - w2);
    
   % --- Logical Condition ---
    % Breaker will ONLY close if time has passed AND all physical limits are met
    if (t > t_min) && (delta_V < delta_V_limit) && (delta_theta < delta_theta_limit) && (delta_w < delta_w_limit)
        close_signal = 1; % Permit closure
    else
        close_signal = 0; % Block closure
    end
end

== matlab function VSM_model_v3_GFMs_Synch/GFM 2/VSM Control/MATLAB Function ==
function [Kp, Ki] = fcn(t)
    % Define your switching time
    T_switch = 1.5; 

    % --- 1. FAST GAINS (0s to 2s) ---
    % Aggressive gains to force the 230kV voltage to track the ramp
    Kp_fast = 0.02;   
    Ki_fast = 0.4;   

    % --- 2. SLOW GAINS (After 2s) ---
    % Your original stable gains for steady state
    ki_v_ac=4*5.2500e-04;
kp_v_ac=0.001;


    Kp_slow = kp_v_ac;   
    Ki_slow = ki_v_ac; 

    % --- SWITCHING LOGIC ---
    if t < T_switch
        Kp = Kp_fast;
        Ki = Ki_fast;
    else
        Kp = Kp_slow;
        Ki = Ki_slow;
    end
end

== matlab function VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem3/DER/Subsystem1/Subsystem2/DSOGI-PLL/Embedded
MATLAB Function7 ==
function Am = mod(A)
Am= mod(A,2*pi);
end

== matlab function VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem3/DER/Subsystem1/Subsystem2/MATLAB Function ==
function [id_ref, iq_ref] = calculate_current_refs(P_ref_MW, Q_ref_MVAr, v_d, v_q)
    % Convert inputs from MW/MVAr to Watts/VArs
    P_ref = P_ref_MW * 1e6;
    Q_ref = Q_ref_MVAr * 1e6;
    
    % Safeguard to prevent division by zero during faults/voltage dips
    vd_sq_vq_sq = max(v_d^2 + v_q^2, 1e-6);
    
    % General calculation (works even if PLL is slightly misaligned, v_q ~= 0)
    id_ref = (2/3) * (P_ref * v_d + Q_ref * v_q) / vd_sq_vq_sq;
    iq_ref = (2/3) * (P_ref * v_q - Q_ref * v_d) / vd_sq_vq_sq;
    
    % If PLL is perfectly aligned (v_q = 0), this mathematically reduces to:
    % id_ref = (2/3) * (P_ref / v_d)
    % iq_ref = -(2/3) * (Q_ref / v_d)
end

== matlab function VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem3/DER/Subsystem1/Subsystem2/MATLAB Function1 ==
function Q_ref_MVAr = v_var_droop(ud,uq)
% Volt-VAR Droop Controller Parameters (AEMO Compliant)
% The 0.93 Power Factor Rule
% Under NER S5.2.5.1, the Automatic Access Standard requires large generators to be capable of supplying or absorbing reactive power equal to 39.5% of their rated active power.

Pgen_MW_gfl = 20;                       % Target active power: 20 MW
ps_gfl = Pgen_MW_gfl;
V_mag = sqrt(ud^2 + uq^2); % measured
Q_max_MVAr = ps_gfl*0.395;                   % Maximum legal injection (0.93 PF)  39
Q_min_MVAr = -ps_gfl*0.395;  
V_m_gfl=326.6; % Maximum legal absorption (0.93 PF)

V_target_pu = 1.0;                      % Target grid voltage (1.0 pu)
droop_percent = 0.04;                   % 4% Voltage Droop setting

% Calculate the droop gain (Slope of the Volt-VAR curve)
K_q_droop = Q_max_MVAr / droop_percent;  % 197.5 MVAr per 1.0 pu voltage error

    % 1. Convert measured raw voltage to per-unit (pu)
    % V_base_peak is your 326.6 V phase-to-neutral peak base
    V_measured_pu = V_mag/ V_m_gfl;
    
    % 2. Calculate the voltage error
    V_error_pu = V_target_pu - V_measured_pu;
    
    % 3. Apply the Droop Gain to calculate requested Reactive Power
    Q_requested = V_error_pu * K_q_droop;
    
    % 4. Enforce the AEMO Hardware Limits (Saturation)
    if Q_requested > Q_max_MVAr
        Q_ref_MVAr = Q_max_MVAr;
    elseif Q_requested < Q_min_MVAr
        Q_ref_MVAr = Q_min_MVAr;
    else
        Q_ref_MVAr = Q_requested;
    end
    
end

== matlab function VSM_model_v3_GFMs_Synch/GFM 1/VSM Control/Subsystem5/MATLAB Function ==
function [close_signal, delta_V, delta_theta, delta_w] = Sync_Check(V1, V2, theta1, theta2, w1, w2, t)
    % --- Configuration ---
    t_min = 46.5;  % Time in seconds to start checking (e.g., 35s)
    
    % Thresholds for larger DER >1500 kva
    delta_V_limit = 0.03;       % 3% Voltage difference
    deg = 10; % 10 phase angle deviation
    delta_theta_limit = deg * (pi/180); % Phase angle limit
    delta_w_limit = 0.1;      % Frequency slip limit (approx 0.1 Hz)
    
    % --- Calculations ---
    delta_V = abs(V1 - V2);
    % Calculate shortest angle distance accounting for wrap-around
    delta_theta = abs(atan2(sin(theta1-theta2), cos(theta1-theta2))); 
    delta_w = abs(w1 - w2);
    
   % --- Logical Condition ---
    % Breaker will ONLY close if time has passed AND all physical limits are met
    if (t > t_min) && (delta_V < delta_V_limit) && (delta_theta < delta_theta_limit) && (delta_w < delta_w_limit)
        close_signal = 1; % Permit closure
    else
        close_signal = 0; % Block closure
    end
end

== matlab function VSM_model_v3_GFMs_Synch/GFM 2/VSM Control/Subsystem/freq and theta synch/MATLAB Function3 ==
function y = fcn(u, sync)
% u: Input from the PI controller
% sync: Synchronization ON (1) or OFF (0) signal

% 1. Declare a persistent variable to store the last output when sync was ON.
persistent last_u_value;

% Initialize the persistent variable on the first call
if isempty(last_u_value)
    last_u_value = single(0);
end

on = single(sync);

if on == 1
    % 2. Mode: Pre-synchronization ON (Relay is Open)
    % The output tracks the PI controller output (u) and saves it.
    out = single(u);
    last_u_value = out; % Continuously update the value to be held
else
    % 3. Mode: Pre-synchronization OFF (Relay is Closed)
    % The output is the last value saved when sync was ON.
    % The PI controller's input should already be zero as per your design.
    out = last_u_value; 
end

y = out;

end

== matlab function VSM_model_v3_GFMs_Synch/GFM 2/VSM Control/Subsystem/voltage_synch/MATLAB Function3 ==
function y = fcn(u, sync)
% u: Input from the PI controller
% sync: Synchronization ON (1) or OFF (0) signal

% 1. Declare a persistent variable to store the last output when sync was ON.
persistent last_u_value;

% Initialize the persistent variable on the first call
if isempty(last_u_value)
    last_u_value = single(0);
end

on = single(sync);

if on == 1
    % 2. Mode: Pre-synchronization ON (Relay is Open)
    % The output tracks the PI controller output (u) and saves it.
    out = single(u);
    last_u_value = out; % Continuously update the value to be held
else
    % 3. Mode: Pre-synchronization OFF (Relay is Closed)
    % The output is the last value saved when sync was ON.
    % The PI controller's input should already be zero as per your design.
    out = last_u_value; 
end

y = out;

end

== matlab function VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem3/MATLAB Function ==
function [P_W, Q_VAr] = calculate_true_power(Va, Vb, Vc, Ia, Ib, Ic)
    
    % 1. Convert Voltage to Alpha-Beta (Amplitude Invariant)
    Valpha = (2/3) * (Va - 0.5*Vb - 0.5*Vc);
    Vbeta  = (2/3) * (0 - (sqrt(3)/2)*Vb + (sqrt(3)/2)*Vc);
    
    % 2. Convert Current to Alpha-Beta (Amplitude Invariant)
    Ialpha = (2/3) * (Ia - 0.5*Ib - 0.5*Ic);
    Ibeta  = (2/3) * (0 - (sqrt(3)/2)*Ib + (sqrt(3)/2)*Ic);
    
    % 3. Calculate Instantaneous 3-Phase Active Power (Watts)
    P_W = (3/2) * (Valpha * Ialpha + Vbeta * Ibeta);
    
    % 4. Calculate Instantaneous 3-Phase Reactive Power (VAr)
    Q_VAr = (3/2) * (Vbeta * Ialpha - Valpha * Ibeta);
    
end

== matlab function VSM_model_v3_GFMs_Synch/GFM 2/VSM Control/Subsystem/Subsystem5/MATLAB Function ==
function [close_signal, delta_V, delta_theta, delta_w] = Sync_Check(V1, V2, theta1, theta2, w1, w2, t)
    % --- Configuration ---
    t_min = 52.5;  % Time in seconds to start checking (e.g., 35s)
    
    % Thresholds for larger DER >1500 kva
    delta_V_limit = 0.03;       % 3% Voltage difference
    deg = 10; % 10 phase angle deviation
    delta_theta_limit = deg * (pi/180); % Phase angle limit
    delta_w_limit = 0.1;      % Frequency slip limit (approx 0.1 Hz)
    
    % --- Calculations ---
    delta_V = abs(V1 - V2);
    % Calculate shortest angle distance accounting for wrap-around
    delta_theta = abs(atan2(sin(theta1-theta2), cos(theta1-theta2))); 
    delta_w = abs(w1 - w2);
    
   % --- Logical Condition ---
    % Breaker will ONLY close if time has passed AND all physical limits are met
    if (t > t_min) && (delta_V < delta_V_limit) && (delta_theta < delta_theta_limit) && (delta_w < delta_w_limit)
        close_signal = 1; % Permit closure
    else
        close_signal = 0; % Block closure
    end
end

== matlab function VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem3/Subsystem6/Subsystem5/MATLAB Function ==
function [close_signal, delta_V, delta_theta, delta_w] = Sync_Check(V1, V2, theta1, theta2, w1, w2, t,ts_DER)
    % --- Configuration ---
    t_min = ts_DER+3;  % Time in seconds to start checking (e.g., 35s)
    
    % Thresholds for larger DER >1500 kva
    delta_V_limit = 0.03;       % 3% Voltage difference
    deg = 10; % 10 phase angle deviation
    delta_theta_limit = deg * (pi/180); % Phase angle limit
    delta_w_limit = 0.1;      % Frequency slip limit (approx 0.1 Hz)
    
    % --- Calculations ---
    delta_V = abs(V1 - V2);
    % Calculate shortest angle distance accounting for wrap-around
    delta_theta = abs(atan2(sin(theta1-theta2), cos(theta1-theta2))); 
    delta_w = abs(w1 - w2);
    
   % --- Logical Condition ---
    % Breaker will ONLY close if time has passed AND all physical limits are met
    if (t > t_min) && (delta_V < delta_V_limit) && (delta_theta < delta_theta_limit) && (delta_w < delta_w_limit)
        close_signal = 1; % Permit closure
    else
        close_signal = 0; % Block closure
    end
end

== matlab function VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem8/DER/Subsystem1/Subsystem2/DSOGI-PLL/Embedded
MATLAB Function27 ==
function [Vds,Vqs]= park(alpha,beta,As)
Vds=alpha*cos(As)+beta*sin(As);
Vqs=-alpha*sin(As)+beta*cos(As);
end

== matlab function VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem8/DER/Subsystem1/Subsystem2/DSOGI-PLL/Embedded
MATLAB Function7 ==
function Am = mod(A)
Am= mod(A,2*pi);
end

== matlab function VSM_model_v3_GFMs_Synch/GFM 1/VSM Control/voltage_synch/MATLAB Function3 ==
function y = fcn(u, sync)
% u: Input from the PI controller
% sync: Synchronization ON (1) or OFF (0) signal

% 1. Declare a persistent variable to store the last output when sync was ON.
persistent last_u_value;

% Initialize the persistent variable on the first call
if isempty(last_u_value)
    last_u_value = single(0);
end

on = single(sync);

if on == 1
    % 2. Mode: Pre-synchronization ON (Relay is Open)
    % The output tracks the PI controller output (u) and saves it.
    out = single(u);
    last_u_value = out; % Continuously update the value to be held
else
    % 3. Mode: Pre-synchronization OFF (Relay is Closed)
    % The output is the last value saved when sync was ON.
    % The PI controller's input should already be zero as per your design.
    out = last_u_value; 
end

y = out;

end

== matlab function VSM_model_v3_GFMs_Synch/GFM 1/VSM Control/freq and theta synch/MATLAB Function ==
function y = fcn(error,error_w,reset)
out=single(error);
e_w=single(error_w);
band=single(0.2*2*pi);  % Threshold is 0.2Hz

if reset==0 && abs(e_w)<=band 
	out=single(error);
else
    out=single(0);
end
y = single(out);

end

== matlab function VSM_model_v3_GFMs_Synch/GFM 1/VSM Control/freq and theta synch/MATLAB Function2 ==
function y = fcn(u, sync)
% u: Input from the PI controller
% sync: Synchronization ON (1) or OFF (0) signal

% 1. Declare a persistent variable to store the last output when sync was ON.
persistent last_u_value;

% Initialize the persistent variable on the first call
if isempty(last_u_value)
    last_u_value = single(0);
end

on = single(sync);

if on == 1
    % 2. Mode: Pre-synchronization ON (Relay is Open)
    % The output tracks the PI controller output (u) and saves it.
    out = single(u);
    last_u_value = out; % Continuously update the value to be held
else
    % 3. Mode: Pre-synchronization OFF (Relay is Closed)
    % The output is the last value saved when sync was ON.
    % The PI controller's input should already be zero as per your design.
    out = last_u_value; 
end

y = out;

end

== matlab function VSM_model_v3_GFMs_Synch/GFM 1/VSM Control/freq and theta synch/MATLAB Function3 ==
function y = fcn(u, sync)
% u: Input from the PI controller
% sync: Synchronization ON (1) or OFF (0) signal

% 1. Declare a persistent variable to store the last output when sync was ON.
persistent last_u_value;

% Initialize the persistent variable on the first call
if isempty(last_u_value)
    last_u_value = single(0);
end

on = single(sync);

if on == 1
    % 2. Mode: Pre-synchronization ON (Relay is Open)
    % The output tracks the PI controller output (u) and saves it.
    out = single(u);
    last_u_value = out; % Continuously update the value to be held
else
    % 3. Mode: Pre-synchronization OFF (Relay is Closed)
    % The output is the last value saved when sync was ON.
    % The PI controller's input should already be zero as per your design.
    out = last_u_value; 
end

y = out;

end

== matlab function VSM_model_v3_GFMs_Synch/GFM 2/VSM Control/Subsystem/freq and theta synch/MATLAB Function ==
function y = fcn(error,error_w,reset)
out=single(error);
e_w=single(error_w);
band=single(0.2*2*pi);  % Threshold is 0.2Hz

if reset==0 && abs(e_w)<=band 
	out=single(error);
else
    out=single(0);
end
y = single(out);

end
