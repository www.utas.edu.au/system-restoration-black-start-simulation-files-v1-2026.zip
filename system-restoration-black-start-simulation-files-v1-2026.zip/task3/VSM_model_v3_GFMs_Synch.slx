simulink model "VSM_model_v3_GFMs_Synch"  (R2024b)
settings: Solver=ode23tb  StartTime=0.0  StopTime=Tend  FixedStep=T_s  RelTol=1e-3  EnableMultiTasking=on
PostLoadFcn:
  | Tcontrol=20e-6;
InitFcn:
  | Tcontrol=20e-6;
values from neighbouring files (symbols this model uses):
  C_4 = 0.1670*C_b    (= 1.00487241952e-06)    [VSM.m]    (also in VSM_CSIRO.m)
  C_6 = 0.2835*C_b    (= 1.70587623314e-06)    [VSM.m]    (also in VSM_CSIRO.m)
  C_8 = 0.2275*C_b    (= 1.36891302659e-06)    [VSM.m]    (also in VSM_CSIRO.m)
  C_dc = 0.008*(n)    (= 1.6)    [VSM.m]    (also in VSM_CSIRO.m)
  C_f = n*300*10^-6    (= 0.06)    [VSM.m]    (also in VSM_CSIRO.m)
  C_f_gfl = (n_gfl) * Cf_unit_gfl    (= 0.00350140874802)    [DER_param.m]
  D_p = (1/(m_p*w_b))    (= 101321.183642)    [VSM.m]    (also in VSM_CSIRO.m)
  droop_percentage = 5    [VSM.m]    (also in VSM_CSIRO.m = 1)
  I_b_dc = S_b/Vdc_n    [VSM.m]    (also in VSM_CSIRO.m)
  I_b_LV_peak = I_b_LV * sqrt(2)    [VSM.m]
  I_b_SG_peak = I_b_SG * sqrt(2)    [VSM.m]
  i_ll = -1.15*(S_b/Vdc_n)-i_loss_dc    [VSM.m]    (also in VSM_CSIRO.m)
  i_ul = 1.15*(S_b/Vdc_n)+i_loss_dc    [VSM.m]    (also in VSM_CSIRO.m)
  J = D_p*tau_f    (= 2026.42367285)    [VSM.m]    (also in VSM_CSIRO.m)
  k_dc = eta_1/(Vdc_n*m_p)    [VSM.m]    (also in VSM_CSIRO.m)
  K_p = (1/Vdc_n)    [VSM.m]    (also in VSM_CSIRO.m)
  K_r = 1/R_dc    [VSM.m]    (also in VSM_CSIRO.m)
  Kff_i = 1    [VSM.m]    (also in VSM_CSIRO.m)
  Kff_v = 1    [VSM.m]    (also in VSM_CSIRO.m)
  Ki_i = (1/n)*1.19    (= 0.00595)    [VSM.m]    (also in VSM_CSIRO.m)
  Ki_i_gfl = (1/n_gfl) * Ki_i_unit_gfl    (= 0.571198664289)    [DER_param.m]
  Ki_v = (n)*1.161022    (= 232.2044)    [VSM.m]    (also in VSM_CSIRO.m)
  ki_v_ac = 4*5.2500e-04    (= 0.0021)    [VSM.m]    (also in VSM_CSIRO.m)
  Kp_i = 0.738891    [VSM.m]    (also in VSM_CSIRO.m)
  Kp_i_gfl = (1/n_gfl) * Kp_i_unit_gfl    (= 0.00909090909091)    [DER_param.m]
  Kp_v = 0.52    [VSM.m]    (also in VSM_CSIRO.m)
  kp_v_ac = 0.001    [VSM.m]    (also in VSM_CSIRO.m)
  L1_f_gfl = (1/n_gfl) * L1_unit_gfl    (= 1.44686311902e-05)    [DER_param.m]
  L1_pu = 1*0.0186/m    (= 0.000186)    [VSM.m]    (also in VSM_CSIRO.m)
  L1_pu_gfl = 0.03    [DER_param.m]
  L2_f_gfl = (1/n_gfl) * L2_unit_gfl    (= 2.89372623803e-06)    [DER_param.m]
  L2_pu_gfl = 0.03    [DER_param.m]
  L_45 = L_lines(2)    [VSM.m]    (also in VSM_CSIRO.m)
  L_56 = L_lines(3)    [VSM.m]    (also in VSM_CSIRO.m)
  L_67 = L_lines(5)    [VSM.m]    (also in VSM_CSIRO.m)
  L_78 = L_lines(6)    [VSM.m]    (also in VSM_CSIRO.m)
  L_89 = L_lines(8)    [VSM.m]    (also in VSM_CSIRO.m)
  L_94 = L_lines(9)    [VSM.m]    (also in VSM_CSIRO.m)
  L_f = (1/n)*200*10^-6    (= 1e-06)    [VSM.m]    (also in VSM_CSIRO.m)
  Lg = (X_BY_R_gfl * Rg) / wn_gfl    [DER_param.m]    (also in initialcondition_gfm_Pooyan.m = X_BY_R*Rg/(wn); initialcondition_Pooyan.m = X_BY_R*Rg/(wn))
  n = 200    [VSM.m]    (also in VSM_CSIRO.m)
  Pgen_MW_gfl = 20    [DER_param.m]
  ps = base/3    (= 0.75)    [VSM.m]    (also in VSM_CSIRO.m)
  R1_f_gfl = (1/n_gfl) * R1_unit_gfl    (= 0.000909090909091)    [DER_param.m]
  R1_pu = 1*0.00734/m    (= 7.34e-05)    [VSM.m]    (also in VSM_CSIRO.m)
  R1_pu_gfl = 0.005    [DER_param.m]
  R2_f_gfl = (1/n_gfl) * R2_unit_gfl    (= 0.000181818181818)    [DER_param.m]
  R2_pu_gfl = 0.005    [DER_param.m]
  R_45 = R_lines(2)    [VSM.m]    (also in VSM_CSIRO.m)
  R_56 = R_lines(3)    [VSM.m]    (also in VSM_CSIRO.m)
  R_67 = R_lines(5)    [VSM.m]    (also in VSM_CSIRO.m)
  R_78 = R_lines(6)    [VSM.m]    (also in VSM_CSIRO.m)
  R_89 = R_lines(8)    [VSM.m]    (also in VSM_CSIRO.m)
  R_94 = R_lines(9)    [VSM.m]    (also in VSM_CSIRO.m)
  R_base_gfl = (3 * Vg_gfl^2) / (2 * Pn_gfl)    [DER_param.m]
  R_dc = (Vdc_n/(0.05*(S_b)/Vdc_n))    [VSM.m]    (also in VSM_CSIRO.m)
  R_f = 0.001/n    (= 5e-06)    [VSM.m]    (also in VSM_CSIRO.m)
  Rg = (3 * Vg_gfl^2) / (2 * SCR_gfl * sqrt(1 + X_BY_R_gfl^2) * Pn_gfl)    [DER_param.m]    (also in initialcondition_gfm_Pooyan.m = (3*Vg^2)/(2*SCR*sqrt(1+X_BY_R^2)*Pn); initialcondition_Pooyan.m = (3*Vg^2)/(2*SCR*sqrt(1+X_BY_R^2)*Pn))
  S_b = 100*(10^6)    (= 100000000)    [VSM.m]    (also in VSM_CSIRO.m)
  S_bt = S_b    (= 100000000)    [VSM.m]    (also in VSM_CSIRO.m)
  S_bt_gfl = S_b_gfl    (= 22000000)    [DER_param.m]
  T_en = T_load-0.5    (= 24.5)    [VSM.m]    (also in VSM_CSIRO.m = 44.5)
  T_s = 1e-4    (= 0.0001)    [VSM.m]    (also in VSM_CSIRO.m)
  tau_dc = 0.05    [VSM.m]    (also in VSM_CSIRO.m)
  tau_g = 5    [VSM.m]    (also in VSM_CSIRO.m)
  Tend = 90    [VSM.m]    (also in VSM_CSIRO.m = 50)
  ts_DER = 15    [DER_param.m]
  V1_rms = 1000    [VSM.m]    (also in VSM_CSIRO.m)
  V1_rms_gfl = 1000    [DER_param.m]
  V1_rms_tx1_gfl = 1000    [DER_param.m]
  V2_rms = 13800    [VSM.m]    (also in VSM_CSIRO.m)
  V2_rms_tx1_gfl = 13800    [DER_param.m]
  V_b = 230*(10^3)    (= 230000)    [VSM.m]    (also in VSM_CSIRO.m)
  V_m = sqrt(2/3)*V1_rms    [VSM.m]    (also in VSM_CSIRO.m)
  V_m_gfl = sqrt(2/3)*V1_rms_gfl    [DER_param.m]
  V_sg_p = sqrt(2/3)*V2_rms    [VSM.m]
  Vdc_n = 3*V_m    [VSM.m]    (also in VSM_CSIRO.m)
  Vdc_n_gfl = 2300    [DER_param.m]
  w_b = 2*pi*f_b    (= 314.159265359)    [VSM.m]    (also in VSM_CSIRO.m)
  w_b_gfl = 2*pi*f_b_gfl    (= 314.159265359)    [DER_param.m]
  w_f = 2*pi*5    (= 31.4159265359)    [VSM.m]    (also in VSM_CSIRO.m)
undefined symbols (not defined in the file or in its folder): D1, Delta, DiscIntNeverNeededParam, dspblkCoreblockFVToolHelper, gcbh, i_dc, magnitude
libraries: spsSeriesRLCBranchLib x82, spsabctodq0Lib x40, slpidlib x36, spsVoltageMeasurementLib x32, spsThreePhaseVIMeasurementLib x31, spsThreePhaseBreakerLib x26, spsGroundLib x22, spsCurrentMeasurementLib x20, spsPLL3phLib x14, spsThreePhaseTransformerTwoWindingsLib x14, simulink x13, spsThreePhaseSeriesRLCBranchLib x10
(part 4 of 10)

== system VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem8 ==
  Inport : Inport
  Enable : Inport  Port=2
  Breaker6 : spsThreePhaseBreakerLib/Three-Phase Breaker  InitialState=open  SwitchA=on  SwitchB=on  SwitchC=on  SwitchTimes=18  External=on  BreakerResistance=0.01  SnubberResistance=1e6  SnubberCapacitance=inf  Measurements=None
  DER : Subsystem
  Demux : Demux  Outputs=3
  Demux1 : Demux  Outputs=3
  Ground : spsGroundLib/Ground  Commented=on  LConnTagsString=a
  MATLAB Function : MATLAB Function  TreatAsAtomicUnit=on
  Pgen : Display
  Pgen1 : Display
  Scope1 : Scope  NumInputPorts=2
  Scope5 : Scope  NumInputPorts=2
  Subsystem6 : Subsystem  Commented=on
  Three-Phase Series RLC Branch : spsThreePhaseSeriesRLCBranchLib/Three-Phase Series RLC Branch  Commented=on  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=R  Resistance=R_base_gfl  Inductance=1e-3  Capacitance=1e-6  Measurements=None
  Three-Phase V-I Measurement1 : spsThreePhaseVIMeasurementLib/Three-Phase V-I Measurement  VoltageMeasurement=phase-to-ground  SetLabelV=off  LabelV=Vabc  Vpu=off  VpuLL=off  CurrentMeasurement=yes  SetLabelI=off  LabelI=Iabc  Ipu=off  Pbase=100e6  Vbase=500e3  OutputType=Complex  PhasorSimulation=off  PSBequivalent=0
  Three-Phase V-I Measurement4 : spsThreePhaseVIMeasurementLib/Three-Phase V-I Measurement  VoltageMeasurement=phase-to-ground  SetLabelV=off  LabelV=Vabc  Vpu=off  VpuLL=off  CurrentMeasurement=yes  SetLabelI=off  LabelI=Iabc  Ipu=off  Pbase=100e6  Vbase=500e3  OutputType=Complex  PhasorSimulation=off  PSBequivalent=0
  Three-Phase Source : spsThreePhaseSourceLib/Three-Phase Source  Commented=on  InternalConnection=Yg  VoltagePhases=off  Voltage=V1_rms_gfl  PhaseAngle=0  Voltage_phases=[25e3 25e3 25e3]/sqrt(3)  PhaseAngles_phases=[0 -120 +120]  Frequency=50  NonIdealSource=on  SpecifyImpedance=off  Resistance=Rg  Inductance=Lg  ShortCircuitLevel=1000e6  BaseVoltage=V1_rms_gfl  XRratio=7  BusType=swing  Pref=10e3  Qref=0  Prefabc=[10e3, 10e3, 10e3]  Qrefabc=[0, 0, 0]  Qmin=-inf  Qmax=inf
  Connection Port : PMIOPort  Side=Right
  Connection Port1 : PMIOPort  Port=2  Side=Right
  Connection Port2 : PMIOPort  Port=3  Side=Right
  wires:
  Three-Phase V-I Measurement4/1 -> Demux/1, [Vabc_PCC], Scope1/1, Scope5/1
  Inport/1 -> DER/1(P_ref_MW)
  Enable/1 -> Breaker6/1, DER/2(Enable)
  Three-Phase V-I Measurement4/2 -> Demux1/1, Scope5/2
  MATLAB Function/1(P_W) -> Pgen/1
  MATLAB Function/2(Q_VAr) -> Pgen1/1
  Demux/1 -> MATLAB Function/1(Va)
  Demux/2 -> MATLAB Function/2(Vb)
  Demux/3 -> MATLAB Function/3(Vc)
  Demux1/1 -> MATLAB Function/4(Ia)
  Demux1/2 -> MATLAB Function/5(Ib)
  Demux1/3 -> MATLAB Function/6(Ic)
  [Iabc] -> DER/3(Iabc)
  [Vabc_PCC] -> DER/4(Vabc)
  Three-Phase V-I Measurement1/1 -> Scope1/2
  [Vabc_PCC] -> Subsystem6/1(Vabc_PCC)
  [Vabc_DER] -> Subsystem6/2(Vabc_DER)
  Three-Phase V-I Measurement1/2 -> [Iabc]
  connections:
  Three-Phase Series RLC Branch/LConn3 -- Three-Phase Source/RConn3
  Three-Phase Series RLC Branch/LConn1 -- Three-Phase Source/RConn1
  Three-Phase Series RLC Branch/LConn2 -- Three-Phase Source/RConn2
  Three-Phase Series RLC Branch/RConn1 -- Ground/LConn1 -- Three-Phase Series RLC Branch/RConn3 -- Three-Phase Series RLC Branch/RConn2
  Connection Port/RConn1 -- Three-Phase V-I Measurement4/RConn1
  Connection Port2/RConn1 -- Three-Phase V-I Measurement4/RConn3
  Connection Port1/RConn1 -- Three-Phase V-I Measurement4/RConn2
  Breaker6/RConn1 -- Three-Phase V-I Measurement4/LConn1
  Breaker6/RConn2 -- Three-Phase V-I Measurement4/LConn2
  Breaker6/RConn3 -- Three-Phase V-I Measurement4/LConn3
  Three-Phase V-I Measurement1/RConn1 -- Breaker6/LConn1
  Three-Phase V-I Measurement1/RConn2 -- Breaker6/LConn2
  Three-Phase V-I Measurement1/RConn3 -- Breaker6/LConn3
  DER/RConn1 -- Three-Phase V-I Measurement1/LConn1
  DER/RConn2 -- Three-Phase V-I Measurement1/LConn2
  DER/RConn3 -- Three-Phase V-I Measurement1/LConn3

== system VSM_model_v3_GFMs_Synch/Synchronous Machine/Subsystem2 ==
  P_ref : Inport
  speed_ref : Inport  Port=2
  speed : Inport  Port=3
  1/droop : Gain  Gain=1/((droop_percentage/100))
  Delta load setpoint : Sum  Inputs=+-|
  Delta speed : Sum  Inputs=-+|
  throttle : Outport  VectorParamsAs1DForOutWhenUnconnected=off
  wires:
  speed/1 -> Delta speed/2
  1/droop/1 -> Delta load setpoint/2
  Delta speed/1 -> 1/droop/1
  speed_ref/1 -> Delta speed/1
  P_ref/1 -> Delta load setpoint/1
  Delta load setpoint/1 -> throttle/1

== system VSM_model_v3_GFMs_Synch/GFM 1/VSM Control/Subsystem5 ==
  Vpcc_1 : Inport
  Vpcc_2 : Inport  Port=2
  Clock : Clock
  Data Type Conversion : DataTypeConversion  OutDataTypeStr=boolean
  Demux : Demux  Outputs=3
  Demux1 : Demux  Outputs=3
  Display{,1..4} (5 alike) : Display
  Gain : Gain  Gain=1/V_b
  Gain1 : Gain  Gain=1/V_b
  MATLAB Function : MATLAB Function  TreatAsAtomicUnit=on
  Math Function{,1..3} (4 alike) : Math  Operator=magnitude^2
  PLL (3ph)1 : spsPLL3phLib/PLL (3ph)  Fmin=10  Par_Init=[0, 50]  ParK=[180, 3200, 1]  TcD=1e-4  MaxRateChangeFreq=20  FilterCutOffFreq=25  Ts=0  AGC=on
  PLL (3ph)2 : spsPLL3phLib/PLL (3ph)  Fmin=10  Par_Init=[0, 50]  ParK=[180, 3200, 1]  TcD=1e-4  MaxRateChangeFreq=20  FilterCutOffFreq=25  Ts=0  AGC=on
  Scope : Scope
  Sqrt : Sqrt
  Sqrt1 : Sqrt
  Sum : Sum  Inputs=|++
  Sum1 : Sum  Inputs=|++
  Terminator : Terminator
  Terminator1 : Terminator
  abc to dq0 : spsabctodq0Lib/abc to dq0  Alignment=90 degrees behind phase A axis
  abc to dq1 : spsabctodq0Lib/abc to dq0  Alignment=90 degrees behind phase A axis
  close_signal : Outport
  wires:
  PLL (3ph)1/1 -> MATLAB Function/5(w1)
  PLL (3ph)1/2 -> MATLAB Function/3(theta1), abc to dq0/2
  PLL (3ph)2/2 -> abc to dq1/2, MATLAB Function/4(theta2)
  PLL (3ph)2/1 -> MATLAB Function/6(w2)
  abc to dq0/1 -> Demux/1
  Demux/1 -> Math Function/1
  Demux/2 -> Math Function2/1
  Math Function/1 -> Sum/1
  Math Function2/1 -> Sum/2
  Sum/1 -> Sqrt/1
  Demux/3 -> Terminator/1
  Demux1/1 -> Math Function1/1
  abc to dq1/1 -> Demux1/1
  Sum1/1 -> Sqrt1/1
  Demux1/2 -> Math Function3/1
  Demux1/3 -> Terminator1/1
  Math Function1/1 -> Sum1/1
  Math Function3/1 -> Sum1/2
  Sqrt1/1 -> Gain1/1
  MATLAB Function/2(delta_V) -> Display/1
  MATLAB Function/3(delta_theta) -> Scope/1, Display1/1
  MATLAB Function/4(delta_w) -> Display2/1
  Sqrt/1 -> Gain/1
  Gain/1 -> Display3/1, MATLAB Function/1(V1)
  Gain1/1 -> Display4/1, MATLAB Function/2(V2)
  MATLAB Function/1(close_signal) -> Data Type Conversion/1
  Clock/1 -> MATLAB Function/7(t)
  Data Type Conversion/1 -> close_signal/1
  Vpcc_2/1 -> abc to dq1/1, PLL (3ph)2/1
  Vpcc_1/1 -> abc to dq0/1, PLL (3ph)1/1

== system VSM_model_v3_GFMs_Synch/GFM 1/VSM Control/freq and theta synch ==
  In1 : Inport
  In2 : Inport  Port=2
  abc : Inport  Port=3
  sync : Inport  Port=4
  Compare To Zero : simulink/Logic and Bit Operations/Compare To Zero  relop===  OutDataTypeStr=boolean
  Compare To Zero1 : simulink/Logic and Bit Operations/Compare To Zero  relop===  OutDataTypeStr=boolean
  DSOGI-PLL : Subsystem
  Delay : Delay  DelayLength=1  InputProcessing=Columns as channels (frame based)
  Gain : Gain  Gain=2*pi
  Logical Operator : Logic  Operator=NOT  AllPortsSameDT=off  OutDataTypeStr=boolean
  MATLAB Function : MATLAB Function  TreatAsAtomicUnit=on
  MATLAB Function2 : MATLAB Function  TreatAsAtomicUnit=on
  MATLAB Function3 : MATLAB Function  TreatAsAtomicUnit=on
  PID Controller1 : slpidlib/PID Controller  Controller=PI  Form=Parallel  TimeDomain=Discrete-time  UseExternalTs=off  SampleTime=-1  IntegratorMethod=Forward Euler  FilterMethod=Forward Euler  ControllerParametersSource=internal  P=0.2  I=40  UseKiTs=off  D=0  UseExternalDerivativeSource=off  N=100  UseFilter=on  TunerSelectOption=Transfer Function Based (PID Tuner App)  InitialConditionSource=internal  InitialConditionForIntegrator=0  InitialConditionForFilter=0  DifferentiatorICPrevScaledInput=0  ExternalReset=level  TrackingMode=off  Kt=1  LimitOutput=off  SatLimitsSource=internal  UpperSaturationLimit=inf  LowerSaturationLimit=-inf  LinearizeAsGain=on  AntiWindupMode=none  Kb=1  LimitIntegrator=off  UpperIntegratorSaturationLimit=inf  LowerIntegratorSaturationLimit=-inf  POutMin=[]  POutMax=[]  IOutMin=[]  IOutMax=[]  DOutMin=[]  DOutMax=[]  NOutMin=[]  NOutMax=[]  SumOutMin=[]  SumOutMax=[]  SaturationOutMin=[]  SaturationOutMax=[]  PParamMin=[]  PParamMax=[]  IParamMin=[]  IParamMax=[]  DParamMin=[]  DParamMax=[]  NParamMin=[]  NParamMax=[]  KbParamMin=[]  KbParamMax=[]  KtParamMin=[]  KtParamMax=[]  KbOutMin=[]  KbOutMax=[]  KtOutMin=[]  KtOutMax=[]  IntegratorOutMin=[]  IntegratorOutMax=[]  FilterOutMin=[]  FilterOutMax=[]  SumI1OutMin=[]  SumI1OutMax=[]  SumI2OutMin=[]  SumI2OutMax=[]  SumI3OutMin=[]  SumI3OutMax=[]  SumI4OutMin=[]  SumI4OutMax=[]  SumDOutMin=[]  SumDOutMax=[]  DifferentiatorOutMin=[]  DifferentiatorOutMax=[]  FilterDiffOutCoefMin=[]  FilterDiffOutCoefMax=[]  ReciprocalOutMin=[]  ReciprocalOutMax=[]  SumDenOutMin=[]  SumDenOutMax=[]  SumNumOutMin=[]  SumNumOutMax=[]  DivideOutMin=[]  DivideOutMax=[]  UdiffTsProdOutMin=[]  UdiffTsProdOutMax=[]  NTsProdOutMin=[]  NTsProdOutMax=[]  UintegralTsProdOutMin=[]  UintegralTsProdOutMax=[]  UngainTsProdOutMin=[]  UngainTsProdOutMax=[]  ClampingZeroOutDataTypeStr=Inherit: Inherit via back propagation  ClampingZeroOutMin=[]  ClampingZeroOutMax=[]  FilterDenConstantOutDataTypeStr=Inherit: Inherit via back propagation  FilterDenConstantOutMin=[]  FilterDenConstantOutMax=[]  PCopyOutDataTypeStr=Inherit: Inherit via back propagation  PCopyOutMin=[]  PCopyOutMax=[]  NCopyOutDataTypeStr=Inherit: Inherit via back propagation  NCopyOutMin=[]  NCopyOutMax=[]  IntegratorContinuousStateAttributes=''  IntegratorStateMustResolveToSignalObject=off  IntegratorRTWStateStorageClass=Auto  FilterContinuousStateAttributes=''  FilterStateMustResolveToSignalObject=off  FilterRTWStateStorageClass=Auto  ParallelPVariant=InternalParameters  IdealPVariant=Disabled  IVariant=InternalParameters  DVariant=Disabled  IntegratorVariant=Discrete  SatVariant=Disabled  AWVariant=Passthrough  PCopyVariant=Disabled  TRVariant=Disabled  FdbkBlocksVariant=Forward  IdealPFdbkVariant=Disabled  SatFdbkVariant=Disabled  DerivativeFilterVariant=Disabled  NVariant=Disabled  NCopyVariant=Disabled_SignalSpec  FilterICVariant=Disabled  IntegratorICVariant=InternalICs  ExternalResetVariant=ExternalReset  TRSumVariant=Passthrough  SumFdbkVariant=Disabled  SumVariant=Sum_PI  TsampFilterVariant=InternalTs  TsampNgainVariant=Passthrough  TsampIntegralVariant=Disabled_SignalSpec  ExternalSaturationOutDataTypeStr=Inherit: Same as second input  DerivativeSourceVariant=Disabled  PreIntVariant=InternalPreInt
  PID Controller2 : slpidlib/PID Controller  Controller=PI  Form=Parallel  TimeDomain=Discrete-time  UseExternalTs=off  SampleTime=-1  IntegratorMethod=Forward Euler  FilterMethod=Forward Euler  ControllerParametersSource=internal  P=1  I=30  UseKiTs=off  D=0  UseExternalDerivativeSource=off  N=100  UseFilter=on  TunerSelectOption=Transfer Function Based (PID Tuner App)  InitialConditionSource=internal  InitialConditionForIntegrator=0  InitialConditionForFilter=0  DifferentiatorICPrevScaledInput=0  ExternalReset=level  TrackingMode=off  Kt=1  LimitOutput=off  SatLimitsSource=internal  UpperSaturationLimit=inf  LowerSaturationLimit=-inf  LinearizeAsGain=on  AntiWindupMode=none  Kb=1  LimitIntegrator=off  UpperIntegratorSaturationLimit=inf  LowerIntegratorSaturationLimit=-inf  POutMin=[]  POutMax=[]  IOutMin=[]  IOutMax=[]  DOutMin=[]  DOutMax=[]  NOutMin=[]  NOutMax=[]  SumOutMin=[]  SumOutMax=[]  SaturationOutMin=[]  SaturationOutMax=[]  PParamMin=[]  PParamMax=[]  IParamMin=[]  IParamMax=[]  DParamMin=[]  DParamMax=[]  NParamMin=[]  NParamMax=[]  KbParamMin=[]  KbParamMax=[]  KtParamMin=[]  KtParamMax=[]  KbOutMin=[]  KbOutMax=[]  KtOutMin=[]  KtOutMax=[]  IntegratorOutMin=[]  IntegratorOutMax=[]  FilterOutMin=[]  FilterOutMax=[]  SumI1OutMin=[]  SumI1OutMax=[]  SumI2OutMin=[]  SumI2OutMax=[]  SumI3OutMin=[]  SumI3OutMax=[]  SumI4OutMin=[]  SumI4OutMax=[]  SumDOutMin=[]  SumDOutMax=[]  DifferentiatorOutMin=[]  DifferentiatorOutMax=[]  FilterDiffOutCoefMin=[]  FilterDiffOutCoefMax=[]  ReciprocalOutMin=[]  ReciprocalOutMax=[]  SumDenOutMin=[]  SumDenOutMax=[]  SumNumOutMin=[]  SumNumOutMax=[]  DivideOutMin=[]  DivideOutMax=[]  UdiffTsProdOutMin=[]  UdiffTsProdOutMax=[]  NTsProdOutMin=[]  NTsProdOutMax=[]  UintegralTsProdOutMin=[]  UintegralTsProdOutMax=[]  UngainTsProdOutMin=[]  UngainTsProdOutMax=[]  ClampingZeroOutDataTypeStr=Inherit: Inherit via back propagation  ClampingZeroOutMin=[]  ClampingZeroOutMax=[]  FilterDenConstantOutDataTypeStr=Inherit: Inherit via back propagation  FilterDenConstantOutMin=[]  FilterDenConstantOutMax=[]  PCopyOutDataTypeStr=Inherit: Inherit via back propagation  PCopyOutMin=[]  PCopyOutMax=[]  NCopyOutDataTypeStr=Inherit: Inherit via back propagation  NCopyOutMin=[]  NCopyOutMax=[]  IntegratorContinuousStateAttributes=''  IntegratorStateMustResolveToSignalObject=off  IntegratorRTWStateStorageClass=Auto  FilterContinuousStateAttributes=''  FilterStateMustResolveToSignalObject=off  FilterRTWStateStorageClass=Auto  ParallelPVariant=InternalParameters  IdealPVariant=Disabled  IVariant=InternalParameters  DVariant=Disabled  IntegratorVariant=Discrete  SatVariant=Disabled  AWVariant=Passthrough  PCopyVariant=Disabled  TRVariant=Disabled  FdbkBlocksVariant=Forward  IdealPFdbkVariant=Disabled  SatFdbkVariant=Disabled  DerivativeFilterVariant=Disabled  NVariant=Disabled  NCopyVariant=Disabled_SignalSpec  FilterICVariant=Disabled  IntegratorICVariant=InternalICs  ExternalResetVariant=ExternalReset  TRSumVariant=Passthrough  SumFdbkVariant=Disabled  SumVariant=Sum_PI  TsampFilterVariant=InternalTs  TsampNgainVariant=Passthrough  TsampIntegralVariant=Disabled_SignalSpec  ExternalSaturationOutDataTypeStr=Inherit: Same as second input  DerivativeSourceVariant=Disabled  PreIntVariant=InternalPreInt
  PLL (3ph)1 : spsPLL3phLib/PLL (3ph)  Fmin=10  Par_Init=[0, 50]  ParK=[180, 3200, 1]  TcD=1e-4  MaxRateChangeFreq=20  FilterCutOffFreq=25  Ts=0  AGC=on
  Sin : Trigonometry
  Sum3 : Sum  Inputs=-+|
  Sum4 : Sum  Inputs=-+|
  Sum6 : Sum  Inputs=|+-
  Sum7 : Sum  Inputs=|++
  Terminator2 : Terminator
  Terminator3 : Terminator
  Out1 : Outport
  err_theta : Outport  Port=2
  err_w : Outport  Port=3
  wires:
  Delay/1 -> Sum3/1
  Sum7/1 -> Out1/1
  Sum6/1 -> MATLAB Function/2(error_w)
  DSOGI-PLL/4(f) -> Terminator3/1
  Sum4/1 -> err_theta/1, Sin/1, [theta_err]  "err_theta"
  PID Controller1/1 -> MATLAB Function3/1(u)  "delta_w"
  Sin/1 -> MATLAB Function/1(error)
  MATLAB Function/1(y) -> PID Controller2/1
  [w1] -> Sum6/2
  sync/1 -> Logical Operator/1, MATLAB Function2/2(sync), Compare To Zero1/1, Compare To Zero/1, MATLAB Function3/2(sync)
  Sum3/1 -> [w_err], err_w/1, PID Controller1/1  "err_w"
  Compare To Zero/1 -> PID Controller1/2
  PID Controller2/1 -> MATLAB Function2/1(u)  "delta_theta"
  DSOGI-PLL/1(Valp_bet+) -> Terminator2/1
  PLL (3ph)1/1 -> Gain/1
  Compare To Zero1/1 -> PID Controller2/2
  In2/1 -> Sum4/1
  In1/1 -> Delay/1
  Logical Operator/1 -> MATLAB Function/3(reset)
  abc/1 -> DSOGI-PLL/1(abc), PLL (3ph)1/1
  Gain/1 -> Sum6/1, Sum3/2
  MATLAB Function3/1(y) -> Sum7/2  "delta_wt"
  DSOGI-PLL/3(theta_pcc) -> Sum4/2
  MATLAB Function2/1(y) -> Sum7/1  "delta_theta"

== system VSM_model_v3_GFMs_Synch/GFM 1/VSM Control/voltage_synch ==
  In1 : Inport
  sync : Inport  Port=2
  abc : Inport  Port=3
  Compare To Zero2 : simulink/Logic and Bit Operations/Compare To Zero  relop===  OutDataTypeStr=boolean
  Delay1 : Delay  DelayLength=1  InputProcessing=Columns as channels (frame based)
  Demux1 : Demux  Outputs=3
  Demux2 : Demux  Outputs=3
  Fcn1 : Fcn  Expr=sqrt(u[1]^2+u[2]^2)
  Fcn5 : Fcn  Expr=sqrt(u[1]^2+u[2]^2)
  Gain : Gain  Gain=1/V_b
  Gain1 : Gain  Gain=1/V_m
  MATLAB Function3 : MATLAB Function  TreatAsAtomicUnit=on
  Mux1 : Mux  Inputs=2
  Mux5 : Mux  Inputs=2
  PID Controller2 : slpidlib/PID Controller  Controller=PI  Form=Parallel  TimeDomain=Discrete-time  UseExternalTs=off  SampleTime=-1  IntegratorMethod=Forward Euler  FilterMethod=Forward Euler  ControllerParametersSource=internal  P=0.23  I=20  UseKiTs=off  D=0  UseExternalDerivativeSource=off  N=100  UseFilter=on  TunerSelectOption=Transfer Function Based (PID Tuner App)  InitialConditionSource=internal  InitialConditionForIntegrator=0  InitialConditionForFilter=0  DifferentiatorICPrevScaledInput=0  ExternalReset=level  TrackingMode=off  Kt=1  LimitOutput=off  SatLimitsSource=internal  UpperSaturationLimit=inf  LowerSaturationLimit=-inf  LinearizeAsGain=on  AntiWindupMode=none  Kb=1  LimitIntegrator=off  UpperIntegratorSaturationLimit=inf  LowerIntegratorSaturationLimit=-inf  POutMin=[]  POutMax=[]  IOutMin=[]  IOutMax=[]  DOutMin=[]  DOutMax=[]  NOutMin=[]  NOutMax=[]  SumOutMin=[]  SumOutMax=[]  SaturationOutMin=[]  SaturationOutMax=[]  PParamMin=[]  PParamMax=[]  IParamMin=[]  IParamMax=[]  DParamMin=[]  DParamMax=[]  NParamMin=[]  NParamMax=[]  KbParamMin=[]  KbParamMax=[]  KtParamMin=[]  KtParamMax=[]  KbOutMin=[]  KbOutMax=[]  KtOutMin=[]  KtOutMax=[]  IntegratorOutMin=[]  IntegratorOutMax=[]  FilterOutMin=[]  FilterOutMax=[]  SumI1OutMin=[]  SumI1OutMax=[]  SumI2OutMin=[]  SumI2OutMax=[]  SumI3OutMin=[]  SumI3OutMax=[]  SumI4OutMin=[]  SumI4OutMax=[]  SumDOutMin=[]  SumDOutMax=[]  DifferentiatorOutMin=[]  DifferentiatorOutMax=[]  FilterDiffOutCoefMin=[]  FilterDiffOutCoefMax=[]  ReciprocalOutMin=[]  ReciprocalOutMax=[]  SumDenOutMin=[]  SumDenOutMax=[]  SumNumOutMin=[]  SumNumOutMax=[]  DivideOutMin=[]  DivideOutMax=[]  UdiffTsProdOutMin=[]  UdiffTsProdOutMax=[]  NTsProdOutMin=[]  NTsProdOutMax=[]  UintegralTsProdOutMin=[]  UintegralTsProdOutMax=[]  UngainTsProdOutMin=[]  UngainTsProdOutMax=[]  ClampingZeroOutDataTypeStr=Inherit: Inherit via back propagation  ClampingZeroOutMin=[]  ClampingZeroOutMax=[]  FilterDenConstantOutDataTypeStr=Inherit: Inherit via back propagation  FilterDenConstantOutMin=[]  FilterDenConstantOutMax=[]  PCopyOutDataTypeStr=Inherit: Inherit via back propagation  PCopyOutMin=[]  PCopyOutMax=[]  NCopyOutDataTypeStr=Inherit: Inherit via back propagation  NCopyOutMin=[]  NCopyOutMax=[]  IntegratorContinuousStateAttributes=''  IntegratorStateMustResolveToSignalObject=off  IntegratorRTWStateStorageClass=Auto  FilterContinuousStateAttributes=''  FilterStateMustResolveToSignalObject=off  FilterRTWStateStorageClass=Auto  ParallelPVariant=InternalParameters  IdealPVariant=Disabled  IVariant=InternalParameters  DVariant=Disabled  IntegratorVariant=Discrete  SatVariant=Disabled  AWVariant=Passthrough  PCopyVariant=Disabled  TRVariant=Disabled  FdbkBlocksVariant=Forward  IdealPFdbkVariant=Disabled  SatFdbkVariant=Disabled  DerivativeFilterVariant=Disabled  NVariant=Disabled  NCopyVariant=Disabled_SignalSpec  FilterICVariant=Disabled  IntegratorICVariant=InternalICs  ExternalResetVariant=ExternalReset  TRSumVariant=Passthrough  SumFdbkVariant=Disabled  SumVariant=Sum_PI  TsampFilterVariant=InternalTs  TsampNgainVariant=Passthrough  TsampIntegralVariant=Disabled_SignalSpec  ExternalSaturationOutDataTypeStr=Inherit: Same as second input  DerivativeSourceVariant=Disabled  PreIntVariant=InternalPreInt
  Sum9 : Sum  Inputs=+-
  Terminator2 : Terminator
  Terminator3 : Terminator
  Unit Delay : UnitDelay  SampleTime=-1  HasFrameUpgradeWarning=on
  abc to Alpha-Beta-Zero : spsabctoAlphaBetaZeroLib/abc to Alpha-Beta-Zero
  abc to Alpha-Beta-Zero1 : spsabctoAlphaBetaZeroLib/abc to Alpha-Beta-Zero
  delta_v : Outport
  err_V : Outport  Port=2
  wires:
  Demux1/1 -> Mux5/1
  Fcn1/1 -> Gain1/1
  Demux1/2 -> Mux5/2
  Sum9/1 -> err_V/1, [err_V_mag], PID Controller2/1  "err_v"
  Unit Delay/1 -> MATLAB Function3/1(u)
  MATLAB Function3/1(y) -> delta_v/1  "delta_wt"
  sync/1 -> MATLAB Function3/2(sync), Compare To Zero2/1
  PID Controller2/1 -> Unit Delay/1  "delta_v"
  Demux1/3 -> Terminator2/1
  Compare To Zero2/1 -> PID Controller2/2
  Delay1/1 -> Sum9/2
  Mux5/1 -> Fcn5/1
  abc to Alpha-Beta-Zero/1 -> Demux1/1
  Demux2/3 -> Terminator3/1
  abc/1 -> abc to Alpha-Beta-Zero/1
  Mux1/1 -> Fcn1/1
  Demux2/2 -> Mux1/2
  Demux2/1 -> Mux1/1
  abc to Alpha-Beta-Zero1/1 -> Demux2/1
  In1/1 -> abc to Alpha-Beta-Zero1/1
  Gain1/1 -> Delay1/1
  Fcn5/1 -> Gain/1
  Gain/1 -> Sum9/1

== system VSM_model_v3_GFMs_Synch/GFM 2/VSM Control/Subsystem ==
  In1 : Inport
  In2 : Inport  Port=2
  In3 : Inport  Port=3
  R : Inport  Port=4
  Logical Operator : Logic  AllPortsSameDT=off  OutDataTypeStr=boolean
  Logical Operator1 : Logic  Operator=NOT  AllPortsSameDT=off  OutDataTypeStr=boolean
  S-R Flip-Flop1 : simulink_extras/Flip Flops/S-R Flip-Flop  initial_condition=0
  Scope1 : Scope
  Step1 : Step  Time=52.5  SampleTime=0
  Subsystem5 : Subsystem
  Terminator2 : Terminator
  Terminator3 : Terminator
  Terminator4 : Terminator
  Unit Delay1 : UnitDelay  SampleTime=-1  HasFrameUpgradeWarning=on
  freq and theta synch : Subsystem
  voltage_synch : Subsystem
  del_theta : Outport
  delta_v : Outport  Port=2
  !Q : Outport  Port=3
  close_signal : Outport  Port=4
  wires:
  [V_pcc_4] -> Subsystem5/2(Vpcc_2)
  [V_pcc_3] -> Subsystem5/1(Vpcc_1)
  In3/1 -> voltage_synch/1(In1)
  Unit Delay1/1 -> Logical Operator1/1
  Logical Operator1/1 -> Logical Operator/2
  Subsystem5/1(close_signal) -> S-R Flip-Flop1/1
  Step1/1 -> Logical Operator/1
  freq and theta synch/2(err_theta) -> Terminator2/1
  S-R Flip-Flop1/1 -> Unit Delay1/1, close_signal/1
  R/1 -> S-R Flip-Flop1/2
  freq and theta synch/3(err_w) -> Terminator3/1
  Logical Operator/1 -> freq and theta synch/4(sync), voltage_synch/2(sync), Scope1/1
  In1/1 -> freq and theta synch/1(In1)
  [V_pcc_4] -> voltage_synch/3(abc), freq and theta synch/3(abc)
  In2/1 -> freq and theta synch/2(In2)
  S-R Flip-Flop1/2 -> !Q/1
  voltage_synch/1(delta_v) -> delta_v/1
  voltage_synch/2(err_V) -> Terminator4/1
  freq and theta synch/1(Out1) -> del_theta/1

== system VSM_model_v3_GFMs_Synch/Subsystem2/DER 1/Boost ==
  m : Inport
  Bus Selector : BusSelector  OutputSignals=V_PV,I_PV
  Diode : spsDiodeLib/Diode  Ron=0.001  Lon=0  Vf=0.8  IC=0  UseSnubber=0  Rs=500  Cs=250e-9  Measurements=off
  Display : Display
  IGBT/Diode : spsIGBTDiodeLib/IGBT//Diode  Ron=1e-3  Rs=1e5  Cs=inf  Measurements=off
  MATLAB Function1 : MATLAB Function  TreatAsAtomicUnit=on
  MATLAB Function2 : MATLAB Function  TreatAsAtomicUnit=on
  PID Controller : slpidlib/PID Controller  Controller=PI  Form=Parallel  TimeDomain=Continuous-time  UseExternalTs=off  SampleTime=-1  IntegratorMethod=Forward Euler  FilterMethod=Forward Euler  ControllerParametersSource=internal  P=Kp  I=Ki  UseKiTs=off  D=0  UseExternalDerivativeSource=off  N=100  UseFilter=on  TunerSelectOption=Transfer Function Based (PID Tuner App)  InitialConditionSource=internal  InitialConditionForIntegrator=0  InitialConditionForFilter=0  DifferentiatorICPrevScaledInput=0  ExternalReset=none  TrackingMode=off  Kt=1  LimitOutput=on  SatLimitsSource=internal  UpperSaturationLimit=0.95  LowerSaturationLimit=0  LinearizeAsGain=on  AntiWindupMode=none  Kb=1  LimitIntegrator=off  UpperIntegratorSaturationLimit=inf  LowerIntegratorSaturationLimit=-inf  POutMin=[]  POutMax=[]  IOutMin=[]  IOutMax=[]  DOutMin=[]  DOutMax=[]  NOutMin=[]  NOutMax=[]  SumOutMin=[]  SumOutMax=[]  SaturationOutMin=[]  SaturationOutMax=[]  PParamMin=[]  PParamMax=[]  IParamMin=[]  IParamMax=[]  DParamMin=[]  DParamMax=[]  NParamMin=[]  NParamMax=[]  KbParamMin=[]  KbParamMax=[]  KtParamMin=[]  KtParamMax=[]  KbOutMin=[]  KbOutMax=[]  KtOutMin=[]  KtOutMax=[]  IntegratorOutMin=[]  IntegratorOutMax=[]  FilterOutMin=[]  FilterOutMax=[]  SumI1OutMin=[]  SumI1OutMax=[]  SumI2OutMin=[]  SumI2OutMax=[]  SumI3OutMin=[]  SumI3OutMax=[]  SumI4OutMin=[]  SumI4OutMax=[]  SumDOutMin=[]  SumDOutMax=[]  DifferentiatorOutMin=[]  DifferentiatorOutMax=[]  FilterDiffOutCoefMin=[]  FilterDiffOutCoefMax=[]  ReciprocalOutMin=[]  ReciprocalOutMax=[]  SumDenOutMin=[]  SumDenOutMax=[]  SumNumOutMin=[]  SumNumOutMax=[]  DivideOutMin=[]  DivideOutMax=[]  UdiffTsProdOutMin=[]  UdiffTsProdOutMax=[]  NTsProdOutMin=[]  NTsProdOutMax=[]  UintegralTsProdOutMin=[]  UintegralTsProdOutMax=[]  UngainTsProdOutMin=[]  UngainTsProdOutMax=[]  ClampingZeroOutDataTypeStr=Inherit: Inherit via back propagation  ClampingZeroOutMin=[]  ClampingZeroOutMax=[]  FilterDenConstantOutDataTypeStr=Inherit: Inherit via back propagation  FilterDenConstantOutMin=[]  FilterDenConstantOutMax=[]  PCopyOutDataTypeStr=Inherit: Inherit via back propagation  PCopyOutMin=[]  PCopyOutMax=[]  NCopyOutDataTypeStr=Inherit: Inherit via back propagation  NCopyOutMin=[]  NCopyOutMax=[]  IntegratorContinuousStateAttributes=''  IntegratorStateMustResolveToSignalObject=off  IntegratorRTWStateStorageClass=Auto  FilterContinuousStateAttributes=''  FilterStateMustResolveToSignalObject=off  FilterRTWStateStorageClass=Auto  ParallelPVariant=InternalParameters  IdealPVariant=Disabled  IVariant=InternalParameters  DVariant=Disabled  IntegratorVariant=Continuous  SatVariant=Enabled  AWVariant=Passthrough  PCopyVariant=Disabled  TRVariant=Disabled  FdbkBlocksVariant=Forward  IdealPFdbkVariant=Disabled  SatFdbkVariant=Disabled  DerivativeFilterVariant=Disabled  NVariant=Disabled  NCopyVariant=Disabled_SignalSpec  FilterICVariant=Disabled  IntegratorICVariant=InternalICs  ExternalResetVariant=Disabled  TRSumVariant=Passthrough  SumFdbkVariant=Disabled  SumVariant=Sum_PI  TsampFilterVariant=InternalTs  TsampNgainVariant=Passthrough  TsampIntegralVariant=Disabled_SignalSpec  ExternalSaturationOutDataTypeStr=Inherit: Same as second input  DerivativeSourceVariant=Disabled  PreIntVariant=InternalPreInt
  Product : Product
  Relational Operator : RelationalOperator  OutDataTypeStr=boolean
  Repeating Sequence : simulink/Sources/Repeating Sequence  rep_seq_t=[0 0.0002]  rep_seq_y=[0 1]
  Scope1 : Scope
  Series RLC Branch : spsSeriesRLCBranchLib/Series RLC Branch  LConnTagsString=__new0  RConnTagsString=__new0  BranchType=RC  Resistance=RPV  Inductance=1e-3  SetiL0=off  InitialCurrent=0  Capacitance=CPV  Setx0=off  InitialVoltage=0  Measurements=None
  Series RLC Branch1 : spsSeriesRLCBranchLib/Series RLC Branch  LConnTagsString=__new0  RConnTagsString=__new0  BranchType=L  Resistance=RPV  Inductance=L0  SetiL0=off  InitialCurrent=0  Capacitance=CPV  Setx0=off  InitialVoltage=0  Measurements=None
  Series RLC Branch2 : spsSeriesRLCBranchLib/Series RLC Branch  LConnTagsString=__new0  RConnTagsString=__new0  BranchType=C  Resistance=RPV  Inductance=1e-3  SetiL0=off  InitialCurrent=0  Capacitance=C0  Setx0=off  InitialVoltage=0  Measurements=None
  Sum : Sum  Inputs=|-+
  Unit Delay : UnitDelay  SampleTime=1e-4  HasFrameUpgradeWarning=on
  Unit Delay1 : UnitDelay  SampleTime=1e-4  HasFrameUpgradeWarning=on
  PV+ : PMIOPort  Side=Left
  PV- : PMIOPort  Port=2  Side=Left
  UDC+ : PMIOPort  Port=3  Side=Right
  UDC- : PMIOPort  Port=4  Side=Right
  wires:
  m/1 -> Bus Selector/1
  Bus Selector/1 -> Product/1, Unit Delay/1  "<V_PV>"
  Bus Selector/2 -> Product/2, Unit Delay1/1  "<I_PV>"
  Unit Delay/1 -> MATLAB Function1/1(Uk1), Sum/2
  Unit Delay1/1 -> MATLAB Function1/2(Ik1)
  MATLAB Function1/1(Uref) -> Sum/1
  Sum/1 -> PID Controller/1
  PID Controller/1 -> Relational Operator/1
  Repeating Sequence/1 -> Relational Operator/2
  Relational Operator/1 -> [PWM]
  [PWM] -> IGBT/Diode/1
  Product/1 -> Scope1/1, Display/1
  connections:
  Series RLC Branch1/LConn1 -- PV+/RConn1 -- Series RLC Branch/LConn1
  Series RLC Branch2/LConn1 -- UDC+/RConn1 -- Diode/RConn1
  Series RLC Branch1/RConn1 -- Diode/LConn1 -- IGBT/Diode/LConn1
  Series RLC Branch2/RConn1 -- UDC-/RConn1 -- IGBT/Diode/RConn1 -- PV-/RConn1 -- Series RLC Branch/RConn1

== system VSM_model_v3_GFMs_Synch/Subsystem2/DER 1/Boost1 ==
  m : Inport
  Bus Selector : BusSelector  OutputSignals=V_PV,I_PV
  Diode : spsDiodeLib/Diode  Ron=0.001  Lon=0  Vf=0.8  IC=0  UseSnubber=0  Rs=500  Cs=250e-9  Measurements=off
  Display : Display
  IGBT/Diode : spsIGBTDiodeLib/IGBT//Diode  Ron=1e-3  Rs=1e5  Cs=inf  Measurements=off
  MATLAB Function1 : MATLAB Function  TreatAsAtomicUnit=on
  MATLAB Function2 : MATLAB Function  TreatAsAtomicUnit=on
  PID Controller : slpidlib/PID Controller  Controller=PI  Form=Parallel  TimeDomain=Continuous-time  UseExternalTs=off  SampleTime=-1  IntegratorMethod=Forward Euler  FilterMethod=Forward Euler  ControllerParametersSource=internal  P=Kp  I=Ki  UseKiTs=off  D=0  UseExternalDerivativeSource=off  N=100  UseFilter=on  TunerSelectOption=Transfer Function Based (PID Tuner App)  InitialConditionSource=internal  InitialConditionForIntegrator=0  InitialConditionForFilter=0  DifferentiatorICPrevScaledInput=0  ExternalReset=none  TrackingMode=off  Kt=1  LimitOutput=on  SatLimitsSource=internal  UpperSaturationLimit=0.95  LowerSaturationLimit=0  LinearizeAsGain=on  AntiWindupMode=none  Kb=1  LimitIntegrator=off  UpperIntegratorSaturationLimit=inf  LowerIntegratorSaturationLimit=-inf  POutMin=[]  POutMax=[]  IOutMin=[]  IOutMax=[]  DOutMin=[]  DOutMax=[]  NOutMin=[]  NOutMax=[]  SumOutMin=[]  SumOutMax=[]  SaturationOutMin=[]  SaturationOutMax=[]  PParamMin=[]  PParamMax=[]  IParamMin=[]  IParamMax=[]  DParamMin=[]  DParamMax=[]  NParamMin=[]  NParamMax=[]  KbParamMin=[]  KbParamMax=[]  KtParamMin=[]  KtParamMax=[]  KbOutMin=[]  KbOutMax=[]  KtOutMin=[]  KtOutMax=[]  IntegratorOutMin=[]  IntegratorOutMax=[]  FilterOutMin=[]  FilterOutMax=[]  SumI1OutMin=[]  SumI1OutMax=[]  SumI2OutMin=[]  SumI2OutMax=[]  SumI3OutMin=[]  SumI3OutMax=[]  SumI4OutMin=[]  SumI4OutMax=[]  SumDOutMin=[]  SumDOutMax=[]  DifferentiatorOutMin=[]  DifferentiatorOutMax=[]  FilterDiffOutCoefMin=[]  FilterDiffOutCoefMax=[]  ReciprocalOutMin=[]  ReciprocalOutMax=[]  SumDenOutMin=[]  SumDenOutMax=[]  SumNumOutMin=[]  SumNumOutMax=[]  DivideOutMin=[]  DivideOutMax=[]  UdiffTsProdOutMin=[]  UdiffTsProdOutMax=[]  NTsProdOutMin=[]  NTsProdOutMax=[]  UintegralTsProdOutMin=[]  UintegralTsProdOutMax=[]  UngainTsProdOutMin=[]  UngainTsProdOutMax=[]  ClampingZeroOutDataTypeStr=Inherit: Inherit via back propagation  ClampingZeroOutMin=[]  ClampingZeroOutMax=[]  FilterDenConstantOutDataTypeStr=Inherit: Inherit via back propagation  FilterDenConstantOutMin=[]  FilterDenConstantOutMax=[]  PCopyOutDataTypeStr=Inherit: Inherit via back propagation  PCopyOutMin=[]  PCopyOutMax=[]  NCopyOutDataTypeStr=Inherit: Inherit via back propagation  NCopyOutMin=[]  NCopyOutMax=[]  IntegratorContinuousStateAttributes=''  IntegratorStateMustResolveToSignalObject=off  IntegratorRTWStateStorageClass=Auto  FilterContinuousStateAttributes=''  FilterStateMustResolveToSignalObject=off  FilterRTWStateStorageClass=Auto  ParallelPVariant=InternalParameters  IdealPVariant=Disabled  IVariant=InternalParameters  DVariant=Disabled  IntegratorVariant=Continuous  SatVariant=Enabled  AWVariant=Passthrough  PCopyVariant=Disabled  TRVariant=Disabled  FdbkBlocksVariant=Forward  IdealPFdbkVariant=Disabled  SatFdbkVariant=Disabled  DerivativeFilterVariant=Disabled  NVariant=Disabled  NCopyVariant=Disabled_SignalSpec  FilterICVariant=Disabled  IntegratorICVariant=InternalICs  ExternalResetVariant=Disabled  TRSumVariant=Passthrough  SumFdbkVariant=Disabled  SumVariant=Sum_PI  TsampFilterVariant=InternalTs  TsampNgainVariant=Passthrough  TsampIntegralVariant=Disabled_SignalSpec  ExternalSaturationOutDataTypeStr=Inherit: Same as second input  DerivativeSourceVariant=Disabled  PreIntVariant=InternalPreInt
  Product : Product
  Relational Operator : RelationalOperator  OutDataTypeStr=boolean
  Repeating Sequence : simulink/Sources/Repeating Sequence  rep_seq_t=[0 0.0002]  rep_seq_y=[0 1]
  Scope1 : Scope
  Series RLC Branch : spsSeriesRLCBranchLib/Series RLC Branch  LConnTagsString=__new0  RConnTagsString=__new0  BranchType=RC  Resistance=RPV  Inductance=1e-3  SetiL0=off  InitialCurrent=0  Capacitance=CPV  Setx0=off  InitialVoltage=0  Measurements=None
  Series RLC Branch1 : spsSeriesRLCBranchLib/Series RLC Branch  LConnTagsString=__new0  RConnTagsString=__new0  BranchType=L  Resistance=RPV  Inductance=L0  SetiL0=off  InitialCurrent=0  Capacitance=CPV  Setx0=off  InitialVoltage=0  Measurements=None
  Series RLC Branch2 : spsSeriesRLCBranchLib/Series RLC Branch  LConnTagsString=__new0  RConnTagsString=__new0  BranchType=C  Resistance=RPV  Inductance=1e-3  SetiL0=off  InitialCurrent=0  Capacitance=C0  Setx0=off  InitialVoltage=0  Measurements=None
  Sum : Sum  Inputs=|-+
  Unit Delay : UnitDelay  SampleTime=1e-4  HasFrameUpgradeWarning=on
  Unit Delay1 : UnitDelay  SampleTime=1e-4  HasFrameUpgradeWarning=on
  PV+ : PMIOPort  Side=Left
  PV- : PMIOPort  Port=2  Side=Left
  UDC+ : PMIOPort  Port=3  Side=Right
  UDC- : PMIOPort  Port=4  Side=Right
  wires:
  m/1 -> Bus Selector/1
  Bus Selector/1 -> Product/1, Unit Delay/1  "<V_PV>"
  Bus Selector/2 -> Product/2, Unit Delay1/1  "<I_PV>"
  Unit Delay/1 -> MATLAB Function1/1(Uk1), Sum/2
  Unit Delay1/1 -> MATLAB Function1/2(Ik1)
  MATLAB Function1/1(Uref) -> Sum/1
  Sum/1 -> PID Controller/1
  PID Controller/1 -> Relational Operator/1
  Repeating Sequence/1 -> Relational Operator/2
  Relational Operator/1 -> [PWM]
  [PWM] -> IGBT/Diode/1
  Product/1 -> Scope1/1, Display/1
  connections:
  Series RLC Branch1/LConn1 -- PV+/RConn1 -- Series RLC Branch/LConn1
  Series RLC Branch2/LConn1 -- UDC+/RConn1 -- Diode/RConn1
  Series RLC Branch1/RConn1 -- Diode/LConn1 -- IGBT/Diode/LConn1
  Series RLC Branch2/RConn1 -- UDC-/RConn1 -- IGBT/Diode/RConn1 -- PV-/RConn1 -- Series RLC Branch/RConn1

== system VSM_model_v3_GFMs_Synch/Subsystem2/DER 1/LCL Filter ==
  Cf : spsSeriesRLCBranchLib/Series RLC Branch  LConnTagsString=__new0  RConnTagsString=__new0  BranchType=RC  Resistance=200  Inductance=0.0058  SetiL0=off  InitialCurrent=0  Capacitance=50e-6  Setx0=off  InitialVoltage=0  Measurements=None
  Cf1 : spsSeriesRLCBranchLib/Series RLC Branch  LConnTagsString=__new0  RConnTagsString=__new0  BranchType=RC  Resistance=200  Inductance=0.0058  SetiL0=off  InitialCurrent=0  Capacitance=50e-6  Setx0=off  InitialVoltage=0  Measurements=None
  Cf2 : spsSeriesRLCBranchLib/Series RLC Branch  LConnTagsString=__new0  RConnTagsString=__new0  BranchType=RC  Resistance=200  Inductance=0.0058  SetiL0=off  InitialCurrent=0  Capacitance=50e-6  Setx0=off  InitialVoltage=0  Measurements=None
  Ground : spsGroundLib/Ground  LConnTagsString=a
  Lg : spsSeriesRLCBranchLib/Series RLC Branch  LConnTagsString=__new0  RConnTagsString=__new0  BranchType=L  Resistance=0.2  Inductance=2e-3  SetiL0=off  InitialCurrent=0  Capacitance=1e-6  Setx0=off  InitialVoltage=0  Measurements=None
  Linv : spsSeriesRLCBranchLib/Series RLC Branch  LConnTagsString=__new0  RConnTagsString=__new0  BranchType=RL  Resistance=0.2  Inductance=1e-3  SetiL0=off  InitialCurrent=0  Capacitance=1e-6  Setx0=off  InitialVoltage=0  Measurements=None
  Series RLC Branch1 : spsSeriesRLCBranchLib/Series RLC Branch  LConnTagsString=__new0  RConnTagsString=__new0  BranchType=RL  Resistance=0.2  Inductance=1e-3  SetiL0=off  InitialCurrent=0  Capacitance=1e-6  Setx0=off  InitialVoltage=0  Measurements=None
  Series RLC Branch2 : spsSeriesRLCBranchLib/Series RLC Branch  LConnTagsString=__new0  RConnTagsString=__new0  BranchType=RL  Resistance=0.2  Inductance=1e-3  SetiL0=off  InitialCurrent=0  Capacitance=1e-6  Setx0=off  InitialVoltage=0  Measurements=None
  Series RLC Branch3 : spsSeriesRLCBranchLib/Series RLC Branch  LConnTagsString=__new0  RConnTagsString=__new0  BranchType=L  Resistance=0.2  Inductance=2e-3  SetiL0=off  InitialCurrent=0  Capacitance=1e-6  Setx0=off  InitialVoltage=0  Measurements=None
  Series RLC Branch4 : spsSeriesRLCBranchLib/Series RLC Branch  LConnTagsString=__new0  RConnTagsString=__new0  BranchType=L  Resistance=0.2  Inductance=2e-3  SetiL0=off  InitialCurrent=0  Capacitance=1e-6  Setx0=off  InitialVoltage=0  Measurements=None
  Three-Phase V-I Measurement : spsThreePhaseVIMeasurementLib/Three-Phase V-I Measurement  VoltageMeasurement=phase-to-phase  SetLabelV=on  LabelV=Vabc_B2  Vpu=off  VpuLL=off  CurrentMeasurement=no  SetLabelI=off  LabelI=Iabc  Ipu=off  Pbase=100e6  Vbase=500e3  OutputType=Complex  PhasorSimulation=off  PSBequivalent=0
  A : PMIOPort  Side=Left
  a : PMIOPort  Port=2  Side=Right
  B : PMIOPort  Port=3  Side=Left
  b : PMIOPort  Port=4  Side=Right
  C : PMIOPort  Port=5  Side=Left
  c : PMIOPort  Port=6  Side=Right
  connections:
  A/RConn1 -- Linv/LConn1
  B/RConn1 -- Series RLC Branch1/LConn1
  C/RConn1 -- Series RLC Branch2/LConn1
  Linv/RConn1 -- a/RConn1 -- Three-Phase V-I Measurement/LConn1
  Series RLC Branch2/RConn1 -- c/RConn1 -- Three-Phase V-I Measurement/LConn3
  Series RLC Branch1/RConn1 -- b/RConn1 -- Three-Phase V-I Measurement/LConn2
  Cf1/LConn1 -- Ground/LConn1 -- Cf/LConn1 -- Cf2/LConn1
  Cf/RConn1 -- Three-Phase V-I Measurement/RConn1
  Cf1/RConn1 -- Three-Phase V-I Measurement/RConn2
  Cf2/RConn1 -- Three-Phase V-I Measurement/RConn3

== system VSM_model_v3_GFMs_Synch/Subsystem2/DER 1/Subsystem ==
  note: Temperature
  note: Irradiance
  Step : Step  Time=0.2  Before=1012  After=1500  SampleTime=0
  Step1 : Step  Time=0.4  After=-200  SampleTime=0
  Step2 : Step  Time=0.6  After=300  SampleTime=0
  Step3 : Step  Time=0.6  After=-600  SampleTime=0
  Step4 : Step  Time=0.2  Before=30  After=25  SampleTime=0
  Step5 : Step  Time=0.4  After=10  SampleTime=0
  Step6 : Step  Time=0.6  After=-5  SampleTime=0
  Step7 : Step  Time=0.6  After=15  SampleTime=0
  Sum{,1..5} (6 alike) : Sum  Inputs=|++
  Irradiance : Outport
  Temp : Outport  Port=2
  wires:
  Sum/1 -> Sum1/1
  Sum3/1 -> Sum4/1
  Step6/1 -> Sum4/2
  Step7/1 -> Sum5/2
  Sum4/1 -> Sum5/1
  Step/1 -> Sum/1
  Sum1/1 -> Sum2/1
  Step2/1 -> Sum1/2
  Step5/1 -> Sum3/2
  Step3/1 -> Sum2/2
  Step4/1 -> Sum3/1
  Step1/1 -> Sum/2
  Sum2/1 -> Irradiance/1
  Sum5/1 -> Temp/1

== system VSM_model_v3_GFMs_Synch/Subsystem2/DER 1/Subsystem1 ==
  Vabc_B3 : Inport
  Iabc_B3 : Inport  Port=2
  Idref : Inport  Port=3
  Iqref : Inport  Port=4
  Enable : EnablePort  StatesWhenEnabling=reset
  Inverter Control : Subsystem
  Pulses : Outport
  wires:
  Iabc_B3/1 -> Inverter Control/2(Iabc_B3)
  Inverter Control/1(Pulses) -> Pulses/1
  Idref/1 -> Inverter Control/3(Idref)
  Vabc_B3/1 -> Inverter Control/1(Vabc_B3)
  Iqref/1 -> Inverter Control/4(Iqref)
