simulink model "VSM_model_v3_GFMs_Synch"  (R2024b)
settings: Solver=ode23tb  StartTime=0.0  StopTime=Tend  FixedStep=T_s  RelTol=1e-3  EnableMultiTasking=on
PostLoadFcn:
  | Tcontrol=20e-6;
InitFcn:
  | Tcontrol=20e-6;
values from neighbouring files (symbols this model uses):
  C_4 = 0.1670*C_b    (= 1.00487241952e-06)    [VSM.m]    (also in VSM_CSIRO.m)
  C_6 = 0.2835*C_b    (= 1.70587623314e-06)    [VSM.m]    (also in VSM_CSIRO.m)
  C_8 = 0.2275*C_b    (= 1.36891302659e-06)    [VSM.m]    (also in VSM_CSIRO.m)
  C_dc = 0.008*(n)    (= 1.6)    [VSM.m]    (also in VSM_CSIRO.m)
  C_f = n*300*10^-6    (= 0.06)    [VSM.m]    (also in VSM_CSIRO.m)
  C_f_gfl = (n_gfl) * Cf_unit_gfl    (= 0.00350140874802)    [DER_param.m]
  D_p = (1/(m_p*w_b))    (= 101321.183642)    [VSM.m]    (also in VSM_CSIRO.m)
  droop_percentage = 5    [VSM.m]    (also in VSM_CSIRO.m = 1)
  I_b_dc = S_b/Vdc_n    [VSM.m]    (also in VSM_CSIRO.m)
  I_b_LV_peak = I_b_LV * sqrt(2)    [VSM.m]
  I_b_SG_peak = I_b_SG * sqrt(2)    [VSM.m]
  i_ll = -1.15*(S_b/Vdc_n)-i_loss_dc    [VSM.m]    (also in VSM_CSIRO.m)
  i_ul = 1.15*(S_b/Vdc_n)+i_loss_dc    [VSM.m]    (also in VSM_CSIRO.m)
  J = D_p*tau_f    (= 2026.42367285)    [VSM.m]    (also in VSM_CSIRO.m)
  k_dc = eta_1/(Vdc_n*m_p)    [VSM.m]    (also in VSM_CSIRO.m)
  K_p = (1/Vdc_n)    [VSM.m]    (also in VSM_CSIRO.m)
  K_r = 1/R_dc    [VSM.m]    (also in VSM_CSIRO.m)
  Kff_i = 1    [VSM.m]    (also in VSM_CSIRO.m)
  Kff_v = 1    [VSM.m]    (also in VSM_CSIRO.m)
  Ki_i = (1/n)*1.19    (= 0.00595)    [VSM.m]    (also in VSM_CSIRO.m)
  Ki_i_gfl = (1/n_gfl) * Ki_i_unit_gfl    (= 0.571198664289)    [DER_param.m]
  Ki_v = (n)*1.161022    (= 232.2044)    [VSM.m]    (also in VSM_CSIRO.m)
  ki_v_ac = 4*5.2500e-04    (= 0.0021)    [VSM.m]    (also in VSM_CSIRO.m)
  Kp_i = 0.738891    [VSM.m]    (also in VSM_CSIRO.m)
  Kp_i_gfl = (1/n_gfl) * Kp_i_unit_gfl    (= 0.00909090909091)    [DER_param.m]
  Kp_v = 0.52    [VSM.m]    (also in VSM_CSIRO.m)
  kp_v_ac = 0.001    [VSM.m]    (also in VSM_CSIRO.m)
  L1_f_gfl = (1/n_gfl) * L1_unit_gfl    (= 1.44686311902e-05)    [DER_param.m]
  L1_pu = 1*0.0186/m    (= 0.000186)    [VSM.m]    (also in VSM_CSIRO.m)
  L1_pu_gfl = 0.03    [DER_param.m]
  L2_f_gfl = (1/n_gfl) * L2_unit_gfl    (= 2.89372623803e-06)    [DER_param.m]
  L2_pu_gfl = 0.03    [DER_param.m]
  L_45 = L_lines(2)    [VSM.m]    (also in VSM_CSIRO.m)
  L_56 = L_lines(3)    [VSM.m]    (also in VSM_CSIRO.m)
  L_67 = L_lines(5)    [VSM.m]    (also in VSM_CSIRO.m)
  L_78 = L_lines(6)    [VSM.m]    (also in VSM_CSIRO.m)
  L_89 = L_lines(8)    [VSM.m]    (also in VSM_CSIRO.m)
  L_94 = L_lines(9)    [VSM.m]    (also in VSM_CSIRO.m)
  L_f = (1/n)*200*10^-6    (= 1e-06)    [VSM.m]    (also in VSM_CSIRO.m)
  Lg = (X_BY_R_gfl * Rg) / wn_gfl    [DER_param.m]    (also in initialcondition_gfm_Pooyan.m = X_BY_R*Rg/(wn); initialcondition_Pooyan.m = X_BY_R*Rg/(wn))
  n = 200    [VSM.m]    (also in VSM_CSIRO.m)
  Pgen_MW_gfl = 20    [DER_param.m]
  ps = base/3    (= 0.75)    [VSM.m]    (also in VSM_CSIRO.m)
  R1_f_gfl = (1/n_gfl) * R1_unit_gfl    (= 0.000909090909091)    [DER_param.m]
  R1_pu = 1*0.00734/m    (= 7.34e-05)    [VSM.m]    (also in VSM_CSIRO.m)
  R1_pu_gfl = 0.005    [DER_param.m]
  R2_f_gfl = (1/n_gfl) * R2_unit_gfl    (= 0.000181818181818)    [DER_param.m]
  R2_pu_gfl = 0.005    [DER_param.m]
  R_45 = R_lines(2)    [VSM.m]    (also in VSM_CSIRO.m)
  R_56 = R_lines(3)    [VSM.m]    (also in VSM_CSIRO.m)
  R_67 = R_lines(5)    [VSM.m]    (also in VSM_CSIRO.m)
  R_78 = R_lines(6)    [VSM.m]    (also in VSM_CSIRO.m)
  R_89 = R_lines(8)    [VSM.m]    (also in VSM_CSIRO.m)
  R_94 = R_lines(9)    [VSM.m]    (also in VSM_CSIRO.m)
  R_base_gfl = (3 * Vg_gfl^2) / (2 * Pn_gfl)    [DER_param.m]
  R_dc = (Vdc_n/(0.05*(S_b)/Vdc_n))    [VSM.m]    (also in VSM_CSIRO.m)
  R_f = 0.001/n    (= 5e-06)    [VSM.m]    (also in VSM_CSIRO.m)
  Rg = (3 * Vg_gfl^2) / (2 * SCR_gfl * sqrt(1 + X_BY_R_gfl^2) * Pn_gfl)    [DER_param.m]    (also in initialcondition_gfm_Pooyan.m = (3*Vg^2)/(2*SCR*sqrt(1+X_BY_R^2)*Pn); initialcondition_Pooyan.m = (3*Vg^2)/(2*SCR*sqrt(1+X_BY_R^2)*Pn))
  S_b = 100*(10^6)    (= 100000000)    [VSM.m]    (also in VSM_CSIRO.m)
  S_bt = S_b    (= 100000000)    [VSM.m]    (also in VSM_CSIRO.m)
  S_bt_gfl = S_b_gfl    (= 22000000)    [DER_param.m]
  T_en = T_load-0.5    (= 24.5)    [VSM.m]    (also in VSM_CSIRO.m = 44.5)
  T_s = 1e-4    (= 0.0001)    [VSM.m]    (also in VSM_CSIRO.m)
  tau_dc = 0.05    [VSM.m]    (also in VSM_CSIRO.m)
  tau_g = 5    [VSM.m]    (also in VSM_CSIRO.m)
  Tend = 90    [VSM.m]    (also in VSM_CSIRO.m = 50)
  ts_DER = 15    [DER_param.m]
  V1_rms = 1000    [VSM.m]    (also in VSM_CSIRO.m)
  V1_rms_gfl = 1000    [DER_param.m]
  V1_rms_tx1_gfl = 1000    [DER_param.m]
  V2_rms = 13800    [VSM.m]    (also in VSM_CSIRO.m)
  V2_rms_tx1_gfl = 13800    [DER_param.m]
  V_b = 230*(10^3)    (= 230000)    [VSM.m]    (also in VSM_CSIRO.m)
  V_m = sqrt(2/3)*V1_rms    [VSM.m]    (also in VSM_CSIRO.m)
  V_m_gfl = sqrt(2/3)*V1_rms_gfl    [DER_param.m]
  V_sg_p = sqrt(2/3)*V2_rms    [VSM.m]
  Vdc_n = 3*V_m    [VSM.m]    (also in VSM_CSIRO.m)
  Vdc_n_gfl = 2300    [DER_param.m]
  w_b = 2*pi*f_b    (= 314.159265359)    [VSM.m]    (also in VSM_CSIRO.m)
  w_b_gfl = 2*pi*f_b_gfl    (= 314.159265359)    [DER_param.m]
  w_f = 2*pi*5    (= 31.4159265359)    [VSM.m]    (also in VSM_CSIRO.m)
undefined symbols (not defined in the file or in its folder): D1, Delta, DiscIntNeverNeededParam, dspblkCoreblockFVToolHelper, gcbh, i_dc, magnitude
libraries: spsSeriesRLCBranchLib x82, spsabctodq0Lib x40, slpidlib x36, spsVoltageMeasurementLib x32, spsThreePhaseVIMeasurementLib x31, spsThreePhaseBreakerLib x26, spsGroundLib x22, spsCurrentMeasurementLib x20, spsPLL3phLib x14, spsThreePhaseTransformerTwoWindingsLib x14, simulink x13, spsThreePhaseSeriesRLCBranchLib x10
(part 9 of 10)

== system VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem2/DER/Subsystem1/Subsystem2/DSOGI-PLL ==
  note: PI
  note: dqPLL: PID _ filtering
  abc : Inport
  Abs5 : Abs
  Constant : Constant  Value=100*pi
  Constant17 : Constant  Value=100*pi
  Constant18 : Constant  Value=0
  Delay6 : Delay  DelayLength=1
  Delay7 : Delay  DelayLength=1
  Demux1 : Demux  Outputs=2
  Discrete-Time Integrator : DiscreteIntegrator  Commented=on  SampleTime=-1  ICPrevOutput=DiscIntNeverNeededParam  ICPrevScaledInput=DiscIntNeverNeededParam
  Discrete-Time Integrator4 : DiscreteIntegrator  SampleTime=-1  ICPrevOutput=DiscIntNeverNeededParam  ICPrevScaledInput=DiscIntNeverNeededParam
  Embedded MATLAB Function27 : MATLAB Function  TreatAsAtomicUnit=on
  Embedded MATLAB Function7 : MATLAB Function  TreatAsAtomicUnit=on
  Gain2 : Gain  Gain=0.296
  Gain3 : Gain  Gain=0.296/(21.7e-3)
  Gain6 : Gain  Gain=1/2
  PID Controller : slpidlib/PID Controller  Commented=on  Controller=PID  Form=Parallel  TimeDomain=Discrete-time  UseExternalTs=off  SampleTime=-1  IntegratorMethod=Forward Euler  FilterMethod=Forward Euler  ControllerParametersSource=internal  P=10  I=30  UseKiTs=off  D=0  UseExternalDerivativeSource=off  N=100  UseFilter=on  TunerSelectOption=Transfer Function Based (PID Tuner App)  InitialConditionSource=internal  InitialConditionForIntegrator=0  InitialConditionForFilter=0  DifferentiatorICPrevScaledInput=0  ExternalReset=none  TrackingMode=off  Kt=1  LimitOutput=off  SatLimitsSource=internal  UpperSaturationLimit=inf  LowerSaturationLimit=-inf  LinearizeAsGain=on  AntiWindupMode=none  Kb=1  LimitIntegrator=off  UpperIntegratorSaturationLimit=inf  LowerIntegratorSaturationLimit=-inf  POutMin=[]  POutMax=[]  IOutMin=[]  IOutMax=[]  DOutMin=[]  DOutMax=[]  NOutMin=[]  NOutMax=[]  SumOutMin=[]  SumOutMax=[]  SaturationOutMin=[]  SaturationOutMax=[]  PParamMin=[]  PParamMax=[]  IParamMin=[]  IParamMax=[]  DParamMin=[]  DParamMax=[]  NParamMin=[]  NParamMax=[]  KbParamMin=[]  KbParamMax=[]  KtParamMin=[]  KtParamMax=[]  KbOutMin=[]  KbOutMax=[]  KtOutMin=[]  KtOutMax=[]  IntegratorOutMin=[]  IntegratorOutMax=[]  FilterOutMin=[]  FilterOutMax=[]  SumI1OutMin=[]  SumI1OutMax=[]  SumI2OutMin=[]  SumI2OutMax=[]  SumI3OutMin=[]  SumI3OutMax=[]  SumI4OutMin=[]  SumI4OutMax=[]  SumDOutMin=[]  SumDOutMax=[]  DifferentiatorOutMin=[]  DifferentiatorOutMax=[]  FilterDiffOutCoefMin=[]  FilterDiffOutCoefMax=[]  ReciprocalOutMin=[]  ReciprocalOutMax=[]  SumDenOutMin=[]  SumDenOutMax=[]  SumNumOutMin=[]  SumNumOutMax=[]  DivideOutMin=[]  DivideOutMax=[]  UdiffTsProdOutMin=[]  UdiffTsProdOutMax=[]  NTsProdOutMin=[]  NTsProdOutMax=[]  UintegralTsProdOutMin=[]  UintegralTsProdOutMax=[]  UngainTsProdOutMin=[]  UngainTsProdOutMax=[]  ClampingZeroOutDataTypeStr=Inherit: Inherit via back propagation  ClampingZeroOutMin=[]  ClampingZeroOutMax=[]  FilterDenConstantOutDataTypeStr=Inherit: Inherit via back propagation  FilterDenConstantOutMin=[]  FilterDenConstantOutMax=[]  PCopyOutDataTypeStr=Inherit: Inherit via back propagation  PCopyOutMin=[]  PCopyOutMax=[]  NCopyOutDataTypeStr=Inherit: Inherit via back propagation  NCopyOutMin=[]  NCopyOutMax=[]  IntegratorContinuousStateAttributes=''  IntegratorStateMustResolveToSignalObject=off  IntegratorRTWStateStorageClass=Auto  FilterContinuousStateAttributes=''  FilterStateMustResolveToSignalObject=off  FilterRTWStateStorageClass=Auto  ParallelPVariant=InternalParameters  IdealPVariant=Disabled  IVariant=InternalParameters  DVariant=InternalParameters  IntegratorVariant=Discrete  SatVariant=Disabled  AWVariant=Passthrough  PCopyVariant=Disabled  TRVariant=Disabled  FdbkBlocksVariant=Forward  IdealPFdbkVariant=Disabled  SatFdbkVariant=Disabled  DerivativeFilterVariant=ForwardEulerFilter  NVariant=InternalParameters  NCopyVariant=Disabled  FilterICVariant=InternalICsFilter  IntegratorICVariant=InternalICs  ExternalResetVariant=Disabled  TRSumVariant=Passthrough  SumFdbkVariant=Disabled  SumVariant=Sum_PID  TsampFilterVariant=InternalTs  TsampNgainVariant=Passthrough  TsampIntegralVariant=Disabled_SignalSpec  ExternalSaturationOutDataTypeStr=Inherit: Same as second input  DerivativeSourceVariant=ErrorSignal  PreIntVariant=InternalPreInt
  Sum13 : Sum  Inputs=++|
  Sum25 : Sum  Inputs=|++
  Sum37 : Sum  Inputs=|++
  Sum38 : Sum  Inputs=|+-
  Sum39 : Sum  Inputs=|++
  Sum40 : Sum  Inputs=|-+
  Teta_sogi7 : Scope
  Ts3 : SampleTimeMath  TsampMathOp=*
  Vd_sogi7 : Scope
  Vq_sogi7 : Scope
  abc to alpha-beta1 : Subsystem
  integral3 : Subsystem
  integral4 : Subsystem
  theta_pcc : Outport  VectorParamsAs1DForOutWhenUnconnected=off
  wires:
  Discrete-Time Integrator4/1 -> Sum25/2
  Gain3/1 -> Discrete-Time Integrator4/1
  Abs5/1 -> Gain6/1
  Gain2/1 -> Sum25/1
  Constant17/1 -> Sum37/2
  Gain6/1 -> Vd_sogi7/1
  Constant18/1 -> Sum40/1
  Sum37/1 -> Ts3/1, [w4]
  Delay6/1 -> [Teta_sogi9], Embedded MATLAB Function27/3(As), Teta_sogi7/1
  Sum13/1 -> Embedded MATLAB Function7/1(A)
  Delay7/1 -> Sum13/1
  Ts3/1 -> Sum13/2
  abc/1 -> abc to alpha-beta1/1(abc)
  abc to alpha-beta1/1(al_be) -> Demux1/1
  Demux1/1 -> integral3/1(Vg)
  Demux1/2 -> integral4/1(Vg)
  Constant/1 -> integral3/2(W), integral4/2(W)
  integral3/1(v) -> Sum38/1
  integral3/2(qv) -> Sum39/1
  Sum38/1 -> Embedded MATLAB Function27/1(alpha)
  Sum39/1 -> Embedded MATLAB Function27/2(beta)
  integral4/2(qv) -> Sum38/2
  integral4/1(v) -> Sum39/2
  Embedded MATLAB Function27/1(Vds) -> Abs5/1
  Embedded MATLAB Function27/2(Vqs) -> Vq_sogi7/1, Sum40/2
  Sum40/1 -> Gain3/1, Gain2/1
  Embedded MATLAB Function7/1(Am) -> Delay6/1, Delay7/1
  [Teta_sogi9] -> theta_pcc/1
  Sum25/1 -> Sum37/1

== system VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem3/DER/Subsystem1/Subsystem2/DSOGI-PLL ==
  note: PI
  note: dqPLL: PID _ filtering
  abc : Inport
  Abs5 : Abs
  Constant : Constant  Value=100*pi
  Constant17 : Constant  Value=100*pi
  Constant18 : Constant  Value=0
  Delay6 : Delay  DelayLength=1
  Delay7 : Delay  DelayLength=1
  Demux1 : Demux  Outputs=2
  Discrete-Time Integrator : DiscreteIntegrator  Commented=on  SampleTime=-1  ICPrevOutput=DiscIntNeverNeededParam  ICPrevScaledInput=DiscIntNeverNeededParam
  Discrete-Time Integrator4 : DiscreteIntegrator  SampleTime=-1  ICPrevOutput=DiscIntNeverNeededParam  ICPrevScaledInput=DiscIntNeverNeededParam
  Embedded MATLAB Function27 : MATLAB Function  TreatAsAtomicUnit=on
  Embedded MATLAB Function7 : MATLAB Function  TreatAsAtomicUnit=on
  Gain2 : Gain  Gain=0.296
  Gain3 : Gain  Gain=0.296/(21.7e-3)
  Gain6 : Gain  Gain=1/2
  PID Controller : slpidlib/PID Controller  Commented=on  Controller=PID  Form=Parallel  TimeDomain=Discrete-time  UseExternalTs=off  SampleTime=-1  IntegratorMethod=Forward Euler  FilterMethod=Forward Euler  ControllerParametersSource=internal  P=10  I=30  UseKiTs=off  D=0  UseExternalDerivativeSource=off  N=100  UseFilter=on  TunerSelectOption=Transfer Function Based (PID Tuner App)  InitialConditionSource=internal  InitialConditionForIntegrator=0  InitialConditionForFilter=0  DifferentiatorICPrevScaledInput=0  ExternalReset=none  TrackingMode=off  Kt=1  LimitOutput=off  SatLimitsSource=internal  UpperSaturationLimit=inf  LowerSaturationLimit=-inf  LinearizeAsGain=on  AntiWindupMode=none  Kb=1  LimitIntegrator=off  UpperIntegratorSaturationLimit=inf  LowerIntegratorSaturationLimit=-inf  POutMin=[]  POutMax=[]  IOutMin=[]  IOutMax=[]  DOutMin=[]  DOutMax=[]  NOutMin=[]  NOutMax=[]  SumOutMin=[]  SumOutMax=[]  SaturationOutMin=[]  SaturationOutMax=[]  PParamMin=[]  PParamMax=[]  IParamMin=[]  IParamMax=[]  DParamMin=[]  DParamMax=[]  NParamMin=[]  NParamMax=[]  KbParamMin=[]  KbParamMax=[]  KtParamMin=[]  KtParamMax=[]  KbOutMin=[]  KbOutMax=[]  KtOutMin=[]  KtOutMax=[]  IntegratorOutMin=[]  IntegratorOutMax=[]  FilterOutMin=[]  FilterOutMax=[]  SumI1OutMin=[]  SumI1OutMax=[]  SumI2OutMin=[]  SumI2OutMax=[]  SumI3OutMin=[]  SumI3OutMax=[]  SumI4OutMin=[]  SumI4OutMax=[]  SumDOutMin=[]  SumDOutMax=[]  DifferentiatorOutMin=[]  DifferentiatorOutMax=[]  FilterDiffOutCoefMin=[]  FilterDiffOutCoefMax=[]  ReciprocalOutMin=[]  ReciprocalOutMax=[]  SumDenOutMin=[]  SumDenOutMax=[]  SumNumOutMin=[]  SumNumOutMax=[]  DivideOutMin=[]  DivideOutMax=[]  UdiffTsProdOutMin=[]  UdiffTsProdOutMax=[]  NTsProdOutMin=[]  NTsProdOutMax=[]  UintegralTsProdOutMin=[]  UintegralTsProdOutMax=[]  UngainTsProdOutMin=[]  UngainTsProdOutMax=[]  ClampingZeroOutDataTypeStr=Inherit: Inherit via back propagation  ClampingZeroOutMin=[]  ClampingZeroOutMax=[]  FilterDenConstantOutDataTypeStr=Inherit: Inherit via back propagation  FilterDenConstantOutMin=[]  FilterDenConstantOutMax=[]  PCopyOutDataTypeStr=Inherit: Inherit via back propagation  PCopyOutMin=[]  PCopyOutMax=[]  NCopyOutDataTypeStr=Inherit: Inherit via back propagation  NCopyOutMin=[]  NCopyOutMax=[]  IntegratorContinuousStateAttributes=''  IntegratorStateMustResolveToSignalObject=off  IntegratorRTWStateStorageClass=Auto  FilterContinuousStateAttributes=''  FilterStateMustResolveToSignalObject=off  FilterRTWStateStorageClass=Auto  ParallelPVariant=InternalParameters  IdealPVariant=Disabled  IVariant=InternalParameters  DVariant=InternalParameters  IntegratorVariant=Discrete  SatVariant=Disabled  AWVariant=Passthrough  PCopyVariant=Disabled  TRVariant=Disabled  FdbkBlocksVariant=Forward  IdealPFdbkVariant=Disabled  SatFdbkVariant=Disabled  DerivativeFilterVariant=ForwardEulerFilter  NVariant=InternalParameters  NCopyVariant=Disabled  FilterICVariant=InternalICsFilter  IntegratorICVariant=InternalICs  ExternalResetVariant=Disabled  TRSumVariant=Passthrough  SumFdbkVariant=Disabled  SumVariant=Sum_PID  TsampFilterVariant=InternalTs  TsampNgainVariant=Passthrough  TsampIntegralVariant=Disabled_SignalSpec  ExternalSaturationOutDataTypeStr=Inherit: Same as second input  DerivativeSourceVariant=ErrorSignal  PreIntVariant=InternalPreInt
  Sum13 : Sum  Inputs=++|
  Sum25 : Sum  Inputs=|++
  Sum37 : Sum  Inputs=|++
  Sum38 : Sum  Inputs=|+-
  Sum39 : Sum  Inputs=|++
  Sum40 : Sum  Inputs=|-+
  Teta_sogi7 : Scope
  Ts3 : SampleTimeMath  TsampMathOp=*
  Vd_sogi7 : Scope
  Vq_sogi7 : Scope
  abc to alpha-beta1 : Subsystem
  integral3 : Subsystem
  integral4 : Subsystem
  theta_pcc : Outport  VectorParamsAs1DForOutWhenUnconnected=off
  wires:
  Discrete-Time Integrator4/1 -> Sum25/2
  Gain3/1 -> Discrete-Time Integrator4/1
  Abs5/1 -> Gain6/1
  Gain2/1 -> Sum25/1
  Constant17/1 -> Sum37/2
  Gain6/1 -> Vd_sogi7/1
  Constant18/1 -> Sum40/1
  Sum37/1 -> Ts3/1, [w4]
  Delay6/1 -> [Teta_sogi9], Embedded MATLAB Function27/3(As), Teta_sogi7/1
  Sum13/1 -> Embedded MATLAB Function7/1(A)
  Delay7/1 -> Sum13/1
  Ts3/1 -> Sum13/2
  abc/1 -> abc to alpha-beta1/1(abc)
  abc to alpha-beta1/1(al_be) -> Demux1/1
  Demux1/1 -> integral3/1(Vg)
  Demux1/2 -> integral4/1(Vg)
  Constant/1 -> integral3/2(W), integral4/2(W)
  integral3/1(v) -> Sum38/1
  integral3/2(qv) -> Sum39/1
  Sum38/1 -> Embedded MATLAB Function27/1(alpha)
  Sum39/1 -> Embedded MATLAB Function27/2(beta)
  integral4/2(qv) -> Sum38/2
  integral4/1(v) -> Sum39/2
  Embedded MATLAB Function27/1(Vds) -> Abs5/1
  Embedded MATLAB Function27/2(Vqs) -> Vq_sogi7/1, Sum40/2
  Sum40/1 -> Gain3/1, Gain2/1
  Embedded MATLAB Function7/1(Am) -> Delay6/1, Delay7/1
  [Teta_sogi9] -> theta_pcc/1
  Sum25/1 -> Sum37/1

== system VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem8/DER/Subsystem1/Subsystem2/DSOGI-PLL ==
  note: PI
  note: dqPLL: PID _ filtering
  abc : Inport
  Abs5 : Abs
  Constant : Constant  Value=100*pi
  Constant17 : Constant  Value=100*pi
  Constant18 : Constant  Value=0
  Delay6 : Delay  DelayLength=1
  Delay7 : Delay  DelayLength=1
  Demux1 : Demux  Outputs=2
  Discrete-Time Integrator : DiscreteIntegrator  Commented=on  SampleTime=-1  ICPrevOutput=DiscIntNeverNeededParam  ICPrevScaledInput=DiscIntNeverNeededParam
  Discrete-Time Integrator4 : DiscreteIntegrator  SampleTime=-1  ICPrevOutput=DiscIntNeverNeededParam  ICPrevScaledInput=DiscIntNeverNeededParam
  Embedded MATLAB Function27 : MATLAB Function  TreatAsAtomicUnit=on
  Embedded MATLAB Function7 : MATLAB Function  TreatAsAtomicUnit=on
  Gain2 : Gain  Gain=0.296
  Gain3 : Gain  Gain=0.296/(21.7e-3)
  Gain6 : Gain  Gain=1/2
  PID Controller : slpidlib/PID Controller  Commented=on  Controller=PID  Form=Parallel  TimeDomain=Discrete-time  UseExternalTs=off  SampleTime=-1  IntegratorMethod=Forward Euler  FilterMethod=Forward Euler  ControllerParametersSource=internal  P=10  I=30  UseKiTs=off  D=0  UseExternalDerivativeSource=off  N=100  UseFilter=on  TunerSelectOption=Transfer Function Based (PID Tuner App)  InitialConditionSource=internal  InitialConditionForIntegrator=0  InitialConditionForFilter=0  DifferentiatorICPrevScaledInput=0  ExternalReset=none  TrackingMode=off  Kt=1  LimitOutput=off  SatLimitsSource=internal  UpperSaturationLimit=inf  LowerSaturationLimit=-inf  LinearizeAsGain=on  AntiWindupMode=none  Kb=1  LimitIntegrator=off  UpperIntegratorSaturationLimit=inf  LowerIntegratorSaturationLimit=-inf  POutMin=[]  POutMax=[]  IOutMin=[]  IOutMax=[]  DOutMin=[]  DOutMax=[]  NOutMin=[]  NOutMax=[]  SumOutMin=[]  SumOutMax=[]  SaturationOutMin=[]  SaturationOutMax=[]  PParamMin=[]  PParamMax=[]  IParamMin=[]  IParamMax=[]  DParamMin=[]  DParamMax=[]  NParamMin=[]  NParamMax=[]  KbParamMin=[]  KbParamMax=[]  KtParamMin=[]  KtParamMax=[]  KbOutMin=[]  KbOutMax=[]  KtOutMin=[]  KtOutMax=[]  IntegratorOutMin=[]  IntegratorOutMax=[]  FilterOutMin=[]  FilterOutMax=[]  SumI1OutMin=[]  SumI1OutMax=[]  SumI2OutMin=[]  SumI2OutMax=[]  SumI3OutMin=[]  SumI3OutMax=[]  SumI4OutMin=[]  SumI4OutMax=[]  SumDOutMin=[]  SumDOutMax=[]  DifferentiatorOutMin=[]  DifferentiatorOutMax=[]  FilterDiffOutCoefMin=[]  FilterDiffOutCoefMax=[]  ReciprocalOutMin=[]  ReciprocalOutMax=[]  SumDenOutMin=[]  SumDenOutMax=[]  SumNumOutMin=[]  SumNumOutMax=[]  DivideOutMin=[]  DivideOutMax=[]  UdiffTsProdOutMin=[]  UdiffTsProdOutMax=[]  NTsProdOutMin=[]  NTsProdOutMax=[]  UintegralTsProdOutMin=[]  UintegralTsProdOutMax=[]  UngainTsProdOutMin=[]  UngainTsProdOutMax=[]  ClampingZeroOutDataTypeStr=Inherit: Inherit via back propagation  ClampingZeroOutMin=[]  ClampingZeroOutMax=[]  FilterDenConstantOutDataTypeStr=Inherit: Inherit via back propagation  FilterDenConstantOutMin=[]  FilterDenConstantOutMax=[]  PCopyOutDataTypeStr=Inherit: Inherit via back propagation  PCopyOutMin=[]  PCopyOutMax=[]  NCopyOutDataTypeStr=Inherit: Inherit via back propagation  NCopyOutMin=[]  NCopyOutMax=[]  IntegratorContinuousStateAttributes=''  IntegratorStateMustResolveToSignalObject=off  IntegratorRTWStateStorageClass=Auto  FilterContinuousStateAttributes=''  FilterStateMustResolveToSignalObject=off  FilterRTWStateStorageClass=Auto  ParallelPVariant=InternalParameters  IdealPVariant=Disabled  IVariant=InternalParameters  DVariant=InternalParameters  IntegratorVariant=Discrete  SatVariant=Disabled  AWVariant=Passthrough  PCopyVariant=Disabled  TRVariant=Disabled  FdbkBlocksVariant=Forward  IdealPFdbkVariant=Disabled  SatFdbkVariant=Disabled  DerivativeFilterVariant=ForwardEulerFilter  NVariant=InternalParameters  NCopyVariant=Disabled  FilterICVariant=InternalICsFilter  IntegratorICVariant=InternalICs  ExternalResetVariant=Disabled  TRSumVariant=Passthrough  SumFdbkVariant=Disabled  SumVariant=Sum_PID  TsampFilterVariant=InternalTs  TsampNgainVariant=Passthrough  TsampIntegralVariant=Disabled_SignalSpec  ExternalSaturationOutDataTypeStr=Inherit: Same as second input  DerivativeSourceVariant=ErrorSignal  PreIntVariant=InternalPreInt
  Sum13 : Sum  Inputs=++|
  Sum25 : Sum  Inputs=|++
  Sum37 : Sum  Inputs=|++
  Sum38 : Sum  Inputs=|+-
  Sum39 : Sum  Inputs=|++
  Sum40 : Sum  Inputs=|-+
  Teta_sogi7 : Scope
  Ts3 : SampleTimeMath  TsampMathOp=*
  Vd_sogi7 : Scope
  Vq_sogi7 : Scope
  abc to alpha-beta1 : Subsystem
  integral3 : Subsystem
  integral4 : Subsystem
  theta_pcc : Outport  VectorParamsAs1DForOutWhenUnconnected=off
  wires:
  Discrete-Time Integrator4/1 -> Sum25/2
  Gain3/1 -> Discrete-Time Integrator4/1
  Abs5/1 -> Gain6/1
  Gain2/1 -> Sum25/1
  Constant17/1 -> Sum37/2
  Gain6/1 -> Vd_sogi7/1
  Constant18/1 -> Sum40/1
  Sum37/1 -> Ts3/1, [w4]
  Delay6/1 -> [Teta_sogi9], Embedded MATLAB Function27/3(As), Teta_sogi7/1
  Sum13/1 -> Embedded MATLAB Function7/1(A)
  Delay7/1 -> Sum13/1
  Ts3/1 -> Sum13/2
  abc/1 -> abc to alpha-beta1/1(abc)
  abc to alpha-beta1/1(al_be) -> Demux1/1
  Demux1/1 -> integral3/1(Vg)
  Demux1/2 -> integral4/1(Vg)
  Constant/1 -> integral3/2(W), integral4/2(W)
  integral3/1(v) -> Sum38/1
  integral3/2(qv) -> Sum39/1
  Sum38/1 -> Embedded MATLAB Function27/1(alpha)
  Sum39/1 -> Embedded MATLAB Function27/2(beta)
  integral4/2(qv) -> Sum38/2
  integral4/1(v) -> Sum39/2
  Embedded MATLAB Function27/1(Vds) -> Abs5/1
  Embedded MATLAB Function27/2(Vqs) -> Vq_sogi7/1, Sum40/2
  Sum40/1 -> Gain3/1, Gain2/1
  Embedded MATLAB Function7/1(Am) -> Delay6/1, Delay7/1
  [Teta_sogi9] -> theta_pcc/1
  Sum25/1 -> Sum37/1

== system VSM_model_v3_GFMs_Synch/GFM 2/VSM Control/Subsystem/freq and theta synch/DSOGI-PLL/SRF-PLL/Al_Be_0 to dq0 ==
  Al_Be_0 : Inport
  wt : Inport  Port=2
  Fcn : Fcn  Expr=u[1]*cos(u[4]) + u[2]*sin(u[4])
  Fcn1 : Fcn  Expr=-u[1]*sin(u[4]) + u[2]*cos(u[4])
  Fcn2 : Fcn  Expr=u[3]
  Mux1 : Mux  Inputs=[3 1]
  Mux2 : Mux  Inputs=3
  dq0 : Outport  VectorParamsAs1DForOutWhenUnconnected=off
  wires:
  Mux1/1 -> Fcn/1, Fcn2/1, Fcn1/1
  Fcn1/1 -> Mux2/2
  wt/1 -> Mux1/2
  Mux2/1 -> dq0/1
  Al_Be_0/1 -> Mux1/1
  Fcn2/1 -> Mux2/3
  Fcn/1 -> Mux2/1

== system VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem1/DER/Subsystem1/Subsystem2/DSOGI-PLL/abc to alpha-beta1 ==
  abc : Inport
  Gain1 : Gain  Gain=(2/3)  SaturateOnIntegerOverflow=on
  Gain3 : Gain  Gain="[ 1   -1/2   -1/2; 0   sqrt(3)/2   -sqrt(3)/2 ]"  Multiplication=Matrix(K*u) (u vector)  SaturateOnIntegerOverflow=on
  al_be : Outport  VectorParamsAs1DForOutWhenUnconnected=off
  wires:
  abc/1 -> Gain3/1
  Gain1/1 -> al_be/1
  Gain3/1 -> Gain1/1

== system VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem1/DER/Subsystem1/Subsystem2/DSOGI-PLL/integral3 ==
  Vg : Inport
  W : Inport  Port=2
  Gain7 : Gain  Gain=sqrt(2)
  Integrator : Subsystem
  Integrator1 : Subsystem
  Product3 : Product
  Product4 : Product
  Sum7 : Sum  Inputs=|+-
  Sum8 : Sum  Inputs=|+-
  v : Outport
  qv : Outport  Port=2
  wires:
  Integrator1/1(Out) -> qv/1, Sum7/2
  Gain7/1 -> Sum7/1
  Product4/1 -> Integrator1/1(In)
  Product3/1 -> Integrator/1(In)
  Sum7/1 -> Product3/1
  Sum8/1 -> Gain7/1
  Integrator/1(Out) -> v/1, Product4/1, Sum8/2
  Vg/1 -> Sum8/1
  W/1 -> Product4/2, Product3/2

== system VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem1/DER/Subsystem1/Subsystem2/DSOGI-PLL/integral4 ==
  Vg : Inport
  W : Inport  Port=2
  Gain7 : Gain  Gain=sqrt(2)
  Integrator : Subsystem
  Integrator1 : Subsystem
  Product3 : Product
  Product4 : Product
  Sum7 : Sum  Inputs=|+-
  Sum8 : Sum  Inputs=|+-
  v : Outport
  qv : Outport  Port=2
  wires:
  W/1 -> Product4/2, Product3/2
  Product4/1 -> Integrator1/1(In)
  Gain7/1 -> Sum7/1
  Sum7/1 -> Product3/1
  Product3/1 -> Integrator/1(In)
  Integrator1/1(Out) -> qv/1, Sum7/2
  Integrator/1(Out) -> v/1, Product4/1, Sum8/2
  Vg/1 -> Sum8/1
  Sum8/1 -> Gain7/1

== system VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem2/DER/Subsystem1/Subsystem2/DSOGI-PLL/abc to alpha-beta1 ==
  abc : Inport
  Gain1 : Gain  Gain=(2/3)  SaturateOnIntegerOverflow=on
  Gain3 : Gain  Gain="[ 1   -1/2   -1/2; 0   sqrt(3)/2   -sqrt(3)/2 ]"  Multiplication=Matrix(K*u) (u vector)  SaturateOnIntegerOverflow=on
  al_be : Outport  VectorParamsAs1DForOutWhenUnconnected=off
  wires:
  abc/1 -> Gain3/1
  Gain1/1 -> al_be/1
  Gain3/1 -> Gain1/1

== system VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem2/DER/Subsystem1/Subsystem2/DSOGI-PLL/integral3 ==
  Vg : Inport
  W : Inport  Port=2
  Gain7 : Gain  Gain=sqrt(2)
  Integrator : Subsystem
  Integrator1 : Subsystem
  Product3 : Product
  Product4 : Product
  Sum7 : Sum  Inputs=|+-
  Sum8 : Sum  Inputs=|+-
  v : Outport
  qv : Outport  Port=2
  wires:
  Integrator1/1(Out) -> qv/1, Sum7/2
  Gain7/1 -> Sum7/1
  Product4/1 -> Integrator1/1(In)
  Product3/1 -> Integrator/1(In)
  Sum7/1 -> Product3/1
  Sum8/1 -> Gain7/1
  Integrator/1(Out) -> v/1, Product4/1, Sum8/2
  Vg/1 -> Sum8/1
  W/1 -> Product4/2, Product3/2

== system VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem2/DER/Subsystem1/Subsystem2/DSOGI-PLL/integral4 ==
  Vg : Inport
  W : Inport  Port=2
  Gain7 : Gain  Gain=sqrt(2)
  Integrator : Subsystem
  Integrator1 : Subsystem
  Product3 : Product
  Product4 : Product
  Sum7 : Sum  Inputs=|+-
  Sum8 : Sum  Inputs=|+-
  v : Outport
  qv : Outport  Port=2
  wires:
  W/1 -> Product4/2, Product3/2
  Product4/1 -> Integrator1/1(In)
  Gain7/1 -> Sum7/1
  Sum7/1 -> Product3/1
  Product3/1 -> Integrator/1(In)
  Integrator1/1(Out) -> qv/1, Sum7/2
  Integrator/1(Out) -> v/1, Product4/1, Sum8/2
  Vg/1 -> Sum8/1
  Sum8/1 -> Gain7/1

== system VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem3/DER/Subsystem1/Subsystem2/DSOGI-PLL/abc to alpha-beta1 ==
  abc : Inport
  Gain1 : Gain  Gain=(2/3)  SaturateOnIntegerOverflow=on
  Gain3 : Gain  Gain="[ 1   -1/2   -1/2; 0   sqrt(3)/2   -sqrt(3)/2 ]"  Multiplication=Matrix(K*u) (u vector)  SaturateOnIntegerOverflow=on
  al_be : Outport  VectorParamsAs1DForOutWhenUnconnected=off
  wires:
  abc/1 -> Gain3/1
  Gain1/1 -> al_be/1
  Gain3/1 -> Gain1/1

== system VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem3/DER/Subsystem1/Subsystem2/DSOGI-PLL/integral3 ==
  Vg : Inport
  W : Inport  Port=2
  Gain7 : Gain  Gain=sqrt(2)
  Integrator : Subsystem
  Integrator1 : Subsystem
  Product3 : Product
  Product4 : Product
  Sum7 : Sum  Inputs=|+-
  Sum8 : Sum  Inputs=|+-
  v : Outport
  qv : Outport  Port=2
  wires:
  Integrator1/1(Out) -> qv/1, Sum7/2
  Gain7/1 -> Sum7/1
  Product4/1 -> Integrator1/1(In)
  Product3/1 -> Integrator/1(In)
  Sum7/1 -> Product3/1
  Sum8/1 -> Gain7/1
  Integrator/1(Out) -> v/1, Product4/1, Sum8/2
  Vg/1 -> Sum8/1
  W/1 -> Product4/2, Product3/2

== system VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem3/DER/Subsystem1/Subsystem2/DSOGI-PLL/integral4 ==
  Vg : Inport
  W : Inport  Port=2
  Gain7 : Gain  Gain=sqrt(2)
  Integrator : Subsystem
  Integrator1 : Subsystem
  Product3 : Product
  Product4 : Product
  Sum7 : Sum  Inputs=|+-
  Sum8 : Sum  Inputs=|+-
  v : Outport
  qv : Outport  Port=2
  wires:
  W/1 -> Product4/2, Product3/2
  Product4/1 -> Integrator1/1(In)
  Gain7/1 -> Sum7/1
  Sum7/1 -> Product3/1
  Product3/1 -> Integrator/1(In)
  Integrator1/1(Out) -> qv/1, Sum7/2
  Integrator/1(Out) -> v/1, Product4/1, Sum8/2
  Vg/1 -> Sum8/1
  Sum8/1 -> Gain7/1

== system VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem8/DER/Subsystem1/Subsystem2/DSOGI-PLL/abc to alpha-beta1 ==
  abc : Inport
  Gain1 : Gain  Gain=(2/3)  SaturateOnIntegerOverflow=on
  Gain3 : Gain  Gain="[ 1   -1/2   -1/2; 0   sqrt(3)/2   -sqrt(3)/2 ]"  Multiplication=Matrix(K*u) (u vector)  SaturateOnIntegerOverflow=on
  al_be : Outport  VectorParamsAs1DForOutWhenUnconnected=off
  wires:
  abc/1 -> Gain3/1
  Gain1/1 -> al_be/1
  Gain3/1 -> Gain1/1

== system VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem8/DER/Subsystem1/Subsystem2/DSOGI-PLL/integral3 ==
  Vg : Inport
  W : Inport  Port=2
  Gain7 : Gain  Gain=sqrt(2)
  Integrator : Subsystem
  Integrator1 : Subsystem
  Product3 : Product
  Product4 : Product
  Sum7 : Sum  Inputs=|+-
  Sum8 : Sum  Inputs=|+-
  v : Outport
  qv : Outport  Port=2
  wires:
  Integrator1/1(Out) -> qv/1, Sum7/2
  Gain7/1 -> Sum7/1
  Product4/1 -> Integrator1/1(In)
  Product3/1 -> Integrator/1(In)
  Sum7/1 -> Product3/1
  Sum8/1 -> Gain7/1
  Integrator/1(Out) -> v/1, Product4/1, Sum8/2
  Vg/1 -> Sum8/1
  W/1 -> Product4/2, Product3/2

== system VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem8/DER/Subsystem1/Subsystem2/DSOGI-PLL/integral4 ==
  Vg : Inport
  W : Inport  Port=2
  Gain7 : Gain  Gain=sqrt(2)
  Integrator : Subsystem
  Integrator1 : Subsystem
  Product3 : Product
  Product4 : Product
  Sum7 : Sum  Inputs=|+-
  Sum8 : Sum  Inputs=|+-
  v : Outport
  qv : Outport  Port=2
  wires:
  W/1 -> Product4/2, Product3/2
  Product4/1 -> Integrator1/1(In)
  Gain7/1 -> Sum7/1
  Sum7/1 -> Product3/1
  Product3/1 -> Integrator/1(In)
  Integrator1/1(Out) -> qv/1, Sum7/2
  Integrator/1(Out) -> v/1, Product4/1, Sum8/2
  Vg/1 -> Sum8/1
  Sum8/1 -> Gain7/1

== system VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem1/DER/Subsystem1/Subsystem2/DSOGI-PLL/integral3/Integrator ==
  In : Inport
  Delay1 : Delay  DelayLength=1
  Delay2 : Delay  DelayLength=1
  Delay3 : Delay  DelayLength=1
  Gain : Gain  Gain=Tcontrol/12
  Gain1 : Gain  Gain=23
  Gain2 : Gain  Gain=16
  Gain3 : Gain  Gain=5
  Sum : Sum  Inputs=|+-
  Sum1 : Sum  Inputs=|++
  Sum2 : Sum  Inputs=|++
  Out : Outport
  wires:
  In/1 -> Gain/1
  Delay2/1 -> Gain2/1, Delay3/1
  Delay1/1 -> Sum2/2, Gain1/1, Delay2/1
  Delay3/1 -> Gain3/1
  Gain2/1 -> Sum/2
  Gain1/1 -> Sum/1
  Gain3/1 -> Sum1/2
  Sum/1 -> Sum1/1
  Sum1/1 -> Out/1
  Gain/1 -> Sum2/1
  Sum2/1 -> Delay1/1

== system VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem1/DER/Subsystem1/Subsystem2/DSOGI-PLL/integral3/Integrator1 ==
  In : Inport
  Delay1 : Delay  DelayLength=1
  Delay2 : Delay  DelayLength=1
  Delay3 : Delay  DelayLength=1
  Gain : Gain  Gain=Tcontrol/12
  Gain1 : Gain  Gain=23
  Gain2 : Gain  Gain=16
  Gain3 : Gain  Gain=5
  Sum : Sum  Inputs=|+-
  Sum1 : Sum  Inputs=|++
  Sum2 : Sum  Inputs=|++
  Out : Outport
  wires:
  In/1 -> Gain/1
  Delay2/1 -> Gain2/1, Delay3/1
  Delay1/1 -> Sum2/2, Gain1/1, Delay2/1
  Delay3/1 -> Gain3/1
  Gain2/1 -> Sum/2
  Gain1/1 -> Sum/1
  Gain3/1 -> Sum1/2
  Sum/1 -> Sum1/1
  Sum1/1 -> Out/1
  Gain/1 -> Sum2/1
  Sum2/1 -> Delay1/1

== system VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem1/DER/Subsystem1/Subsystem2/DSOGI-PLL/integral4/Integrator ==
  In : Inport
  Delay1 : Delay  DelayLength=1
  Delay2 : Delay  DelayLength=1
  Delay3 : Delay  DelayLength=1
  Gain : Gain  Gain=Tcontrol/12
  Gain1 : Gain  Gain=23
  Gain2 : Gain  Gain=16
  Gain3 : Gain  Gain=5
  Sum : Sum  Inputs=|+-
  Sum1 : Sum  Inputs=|++
  Sum2 : Sum  Inputs=|++
  Out : Outport
  wires:
  In/1 -> Gain/1
  Delay2/1 -> Gain2/1, Delay3/1
  Delay1/1 -> Sum2/2, Gain1/1, Delay2/1
  Delay3/1 -> Gain3/1
  Gain2/1 -> Sum/2
  Gain1/1 -> Sum/1
  Gain3/1 -> Sum1/2
  Sum/1 -> Sum1/1
  Sum1/1 -> Out/1
  Gain/1 -> Sum2/1
  Sum2/1 -> Delay1/1

== system VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem1/DER/Subsystem1/Subsystem2/DSOGI-PLL/integral4/Integrator1 ==
  In : Inport
  Delay1 : Delay  DelayLength=1
  Delay2 : Delay  DelayLength=1
  Delay3 : Delay  DelayLength=1
  Gain : Gain  Gain=Tcontrol/12
  Gain1 : Gain  Gain=23
  Gain2 : Gain  Gain=16
  Gain3 : Gain  Gain=5
  Sum : Sum  Inputs=|+-
  Sum1 : Sum  Inputs=|++
  Sum2 : Sum  Inputs=|++
  Out : Outport
  wires:
  In/1 -> Gain/1
  Delay2/1 -> Gain2/1, Delay3/1
  Delay1/1 -> Sum2/2, Gain1/1, Delay2/1
  Delay3/1 -> Gain3/1
  Gain2/1 -> Sum/2
  Gain1/1 -> Sum/1
  Gain3/1 -> Sum1/2
  Sum/1 -> Sum1/1
  Sum1/1 -> Out/1
  Gain/1 -> Sum2/1
  Sum2/1 -> Delay1/1

== system VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem2/DER/Subsystem1/Subsystem2/DSOGI-PLL/integral3/Integrator ==
  In : Inport
  Delay1 : Delay  DelayLength=1
  Delay2 : Delay  DelayLength=1
  Delay3 : Delay  DelayLength=1
  Gain : Gain  Gain=Tcontrol/12
  Gain1 : Gain  Gain=23
  Gain2 : Gain  Gain=16
  Gain3 : Gain  Gain=5
  Sum : Sum  Inputs=|+-
  Sum1 : Sum  Inputs=|++
  Sum2 : Sum  Inputs=|++
  Out : Outport
  wires:
  In/1 -> Gain/1
  Delay2/1 -> Gain2/1, Delay3/1
  Delay1/1 -> Sum2/2, Gain1/1, Delay2/1
  Delay3/1 -> Gain3/1
  Gain2/1 -> Sum/2
  Gain1/1 -> Sum/1
  Gain3/1 -> Sum1/2
  Sum/1 -> Sum1/1
  Sum1/1 -> Out/1
  Gain/1 -> Sum2/1
  Sum2/1 -> Delay1/1

== system VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem2/DER/Subsystem1/Subsystem2/DSOGI-PLL/integral3/Integrator1 ==
  In : Inport
  Delay1 : Delay  DelayLength=1
  Delay2 : Delay  DelayLength=1
  Delay3 : Delay  DelayLength=1
  Gain : Gain  Gain=Tcontrol/12
  Gain1 : Gain  Gain=23
  Gain2 : Gain  Gain=16
  Gain3 : Gain  Gain=5
  Sum : Sum  Inputs=|+-
  Sum1 : Sum  Inputs=|++
  Sum2 : Sum  Inputs=|++
  Out : Outport
  wires:
  In/1 -> Gain/1
  Delay2/1 -> Gain2/1, Delay3/1
  Delay1/1 -> Sum2/2, Gain1/1, Delay2/1
  Delay3/1 -> Gain3/1
  Gain2/1 -> Sum/2
  Gain1/1 -> Sum/1
  Gain3/1 -> Sum1/2
  Sum/1 -> Sum1/1
  Sum1/1 -> Out/1
  Gain/1 -> Sum2/1
  Sum2/1 -> Delay1/1

== system VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem2/DER/Subsystem1/Subsystem2/DSOGI-PLL/integral4/Integrator ==
  In : Inport
  Delay1 : Delay  DelayLength=1
  Delay2 : Delay  DelayLength=1
  Delay3 : Delay  DelayLength=1
  Gain : Gain  Gain=Tcontrol/12
  Gain1 : Gain  Gain=23
  Gain2 : Gain  Gain=16
  Gain3 : Gain  Gain=5
  Sum : Sum  Inputs=|+-
  Sum1 : Sum  Inputs=|++
  Sum2 : Sum  Inputs=|++
  Out : Outport
  wires:
  In/1 -> Gain/1
  Delay2/1 -> Gain2/1, Delay3/1
  Delay1/1 -> Sum2/2, Gain1/1, Delay2/1
  Delay3/1 -> Gain3/1
  Gain2/1 -> Sum/2
  Gain1/1 -> Sum/1
  Gain3/1 -> Sum1/2
  Sum/1 -> Sum1/1
  Sum1/1 -> Out/1
  Gain/1 -> Sum2/1
  Sum2/1 -> Delay1/1

== system VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem2/DER/Subsystem1/Subsystem2/DSOGI-PLL/integral4/Integrator1 ==
  In : Inport
  Delay1 : Delay  DelayLength=1
  Delay2 : Delay  DelayLength=1
  Delay3 : Delay  DelayLength=1
  Gain : Gain  Gain=Tcontrol/12
  Gain1 : Gain  Gain=23
  Gain2 : Gain  Gain=16
  Gain3 : Gain  Gain=5
  Sum : Sum  Inputs=|+-
  Sum1 : Sum  Inputs=|++
  Sum2 : Sum  Inputs=|++
  Out : Outport
  wires:
  In/1 -> Gain/1
  Delay2/1 -> Gain2/1, Delay3/1
  Delay1/1 -> Sum2/2, Gain1/1, Delay2/1
  Delay3/1 -> Gain3/1
  Gain2/1 -> Sum/2
  Gain1/1 -> Sum/1
  Gain3/1 -> Sum1/2
  Sum/1 -> Sum1/1
  Sum1/1 -> Out/1
  Gain/1 -> Sum2/1
  Sum2/1 -> Delay1/1

== system VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem3/DER/Subsystem1/Subsystem2/DSOGI-PLL/integral3/Integrator ==
  In : Inport
  Delay1 : Delay  DelayLength=1
  Delay2 : Delay  DelayLength=1
  Delay3 : Delay  DelayLength=1
  Gain : Gain  Gain=Tcontrol/12
  Gain1 : Gain  Gain=23
  Gain2 : Gain  Gain=16
  Gain3 : Gain  Gain=5
  Sum : Sum  Inputs=|+-
  Sum1 : Sum  Inputs=|++
  Sum2 : Sum  Inputs=|++
  Out : Outport
  wires:
  In/1 -> Gain/1
  Delay2/1 -> Gain2/1, Delay3/1
  Delay1/1 -> Sum2/2, Gain1/1, Delay2/1
  Delay3/1 -> Gain3/1
  Gain2/1 -> Sum/2
  Gain1/1 -> Sum/1
  Gain3/1 -> Sum1/2
  Sum/1 -> Sum1/1
  Sum1/1 -> Out/1
  Gain/1 -> Sum2/1
  Sum2/1 -> Delay1/1

== system VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem3/DER/Subsystem1/Subsystem2/DSOGI-PLL/integral3/Integrator1 ==
  In : Inport
  Delay1 : Delay  DelayLength=1
  Delay2 : Delay  DelayLength=1
  Delay3 : Delay  DelayLength=1
  Gain : Gain  Gain=Tcontrol/12
  Gain1 : Gain  Gain=23
  Gain2 : Gain  Gain=16
  Gain3 : Gain  Gain=5
  Sum : Sum  Inputs=|+-
  Sum1 : Sum  Inputs=|++
  Sum2 : Sum  Inputs=|++
  Out : Outport
  wires:
  In/1 -> Gain/1
  Delay2/1 -> Gain2/1, Delay3/1
  Delay1/1 -> Sum2/2, Gain1/1, Delay2/1
  Delay3/1 -> Gain3/1
  Gain2/1 -> Sum/2
  Gain1/1 -> Sum/1
  Gain3/1 -> Sum1/2
  Sum/1 -> Sum1/1
  Sum1/1 -> Out/1
  Gain/1 -> Sum2/1
  Sum2/1 -> Delay1/1

== system VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem3/DER/Subsystem1/Subsystem2/DSOGI-PLL/integral4/Integrator ==
  In : Inport
  Delay1 : Delay  DelayLength=1
  Delay2 : Delay  DelayLength=1
  Delay3 : Delay  DelayLength=1
  Gain : Gain  Gain=Tcontrol/12
  Gain1 : Gain  Gain=23
  Gain2 : Gain  Gain=16
  Gain3 : Gain  Gain=5
  Sum : Sum  Inputs=|+-
  Sum1 : Sum  Inputs=|++
  Sum2 : Sum  Inputs=|++
  Out : Outport
  wires:
  In/1 -> Gain/1
  Delay2/1 -> Gain2/1, Delay3/1
  Delay1/1 -> Sum2/2, Gain1/1, Delay2/1
  Delay3/1 -> Gain3/1
  Gain2/1 -> Sum/2
  Gain1/1 -> Sum/1
  Gain3/1 -> Sum1/2
  Sum/1 -> Sum1/1
  Sum1/1 -> Out/1
  Gain/1 -> Sum2/1
  Sum2/1 -> Delay1/1

== system VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem3/DER/Subsystem1/Subsystem2/DSOGI-PLL/integral4/Integrator1 ==
  In : Inport
  Delay1 : Delay  DelayLength=1
  Delay2 : Delay  DelayLength=1
  Delay3 : Delay  DelayLength=1
  Gain : Gain  Gain=Tcontrol/12
  Gain1 : Gain  Gain=23
  Gain2 : Gain  Gain=16
  Gain3 : Gain  Gain=5
  Sum : Sum  Inputs=|+-
  Sum1 : Sum  Inputs=|++
  Sum2 : Sum  Inputs=|++
  Out : Outport
  wires:
  In/1 -> Gain/1
  Delay2/1 -> Gain2/1, Delay3/1
  Delay1/1 -> Sum2/2, Gain1/1, Delay2/1
  Delay3/1 -> Gain3/1
  Gain2/1 -> Sum/2
  Gain1/1 -> Sum/1
  Gain3/1 -> Sum1/2
  Sum/1 -> Sum1/1
  Sum1/1 -> Out/1
  Gain/1 -> Sum2/1
  Sum2/1 -> Delay1/1

== system VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem8/DER/Subsystem1/Subsystem2/DSOGI-PLL/integral3/Integrator ==
  In : Inport
  Delay1 : Delay  DelayLength=1
  Delay2 : Delay  DelayLength=1
  Delay3 : Delay  DelayLength=1
  Gain : Gain  Gain=Tcontrol/12
  Gain1 : Gain  Gain=23
  Gain2 : Gain  Gain=16
  Gain3 : Gain  Gain=5
  Sum : Sum  Inputs=|+-
  Sum1 : Sum  Inputs=|++
  Sum2 : Sum  Inputs=|++
  Out : Outport
  wires:
  In/1 -> Gain/1
  Delay2/1 -> Gain2/1, Delay3/1
  Delay1/1 -> Sum2/2, Gain1/1, Delay2/1
  Delay3/1 -> Gain3/1
  Gain2/1 -> Sum/2
  Gain1/1 -> Sum/1
  Gain3/1 -> Sum1/2
  Sum/1 -> Sum1/1
  Sum1/1 -> Out/1
  Gain/1 -> Sum2/1
  Sum2/1 -> Delay1/1

== system VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem8/DER/Subsystem1/Subsystem2/DSOGI-PLL/integral3/Integrator1 ==
  In : Inport
  Delay1 : Delay  DelayLength=1
  Delay2 : Delay  DelayLength=1
  Delay3 : Delay  DelayLength=1
  Gain : Gain  Gain=Tcontrol/12
  Gain1 : Gain  Gain=23
  Gain2 : Gain  Gain=16
  Gain3 : Gain  Gain=5
  Sum : Sum  Inputs=|+-
  Sum1 : Sum  Inputs=|++
  Sum2 : Sum  Inputs=|++
  Out : Outport
  wires:
  In/1 -> Gain/1
  Delay2/1 -> Gain2/1, Delay3/1
  Delay1/1 -> Sum2/2, Gain1/1, Delay2/1
  Delay3/1 -> Gain3/1
  Gain2/1 -> Sum/2
  Gain1/1 -> Sum/1
  Gain3/1 -> Sum1/2
  Sum/1 -> Sum1/1
  Sum1/1 -> Out/1
  Gain/1 -> Sum2/1
  Sum2/1 -> Delay1/1

== system VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem8/DER/Subsystem1/Subsystem2/DSOGI-PLL/integral4/Integrator ==
  In : Inport
  Delay1 : Delay  DelayLength=1
  Delay2 : Delay  DelayLength=1
  Delay3 : Delay  DelayLength=1
  Gain : Gain  Gain=Tcontrol/12
  Gain1 : Gain  Gain=23
  Gain2 : Gain  Gain=16
  Gain3 : Gain  Gain=5
  Sum : Sum  Inputs=|+-
  Sum1 : Sum  Inputs=|++
  Sum2 : Sum  Inputs=|++
  Out : Outport
  wires:
  In/1 -> Gain/1
  Delay2/1 -> Gain2/1, Delay3/1
  Delay1/1 -> Sum2/2, Gain1/1, Delay2/1
  Delay3/1 -> Gain3/1
  Gain2/1 -> Sum/2
  Gain1/1 -> Sum/1
  Gain3/1 -> Sum1/2
  Sum/1 -> Sum1/1
  Sum1/1 -> Out/1
  Gain/1 -> Sum2/1
  Sum2/1 -> Delay1/1

== system VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem8/DER/Subsystem1/Subsystem2/DSOGI-PLL/integral4/Integrator1 ==
  In : Inport
  Delay1 : Delay  DelayLength=1
  Delay2 : Delay  DelayLength=1
  Delay3 : Delay  DelayLength=1
  Gain : Gain  Gain=Tcontrol/12
  Gain1 : Gain  Gain=23
  Gain2 : Gain  Gain=16
  Gain3 : Gain  Gain=5
  Sum : Sum  Inputs=|+-
  Sum1 : Sum  Inputs=|++
  Sum2 : Sum  Inputs=|++
  Out : Outport
  wires:
  In/1 -> Gain/1
  Delay2/1 -> Gain2/1, Delay3/1
  Delay1/1 -> Sum2/2, Gain1/1, Delay2/1
  Delay3/1 -> Gain3/1
  Gain2/1 -> Sum/2
  Gain1/1 -> Sum/1
  Gain3/1 -> Sum1/2
  Sum/1 -> Sum1/1
  Sum1/1 -> Out/1
  Gain/1 -> Sum2/1
  Sum2/1 -> Delay1/1

== matlab function VSM_model_v3_GFMs_Synch/GFM 1/VSM Control/MATLAB Function2 ==
function [Kp, Ki] = fcn(t)
    % Define your switching time
    T_switch = 1.5; 

    % --- 1. FAST GAINS (0s to 2s) ---
    % Aggressive gains to force the 230kV voltage to track the ramp
    Kp_fast = 0.02;   
    Ki_fast = 0.4;   

    % --- 2. SLOW GAINS (After 2s) ---
    % Your original stable gains for steady state
    ki_v_ac=4*5.2500e-04;
kp_v_ac=0.001;


    Kp_slow = kp_v_ac;   
    Ki_slow = ki_v_ac; 

    % --- SWITCHING LOGIC ---
    if t < T_switch
        Kp = Kp_fast;
        Ki = Ki_fast;
    else
        Kp = Kp_slow;
        Ki = Ki_slow;
    end
end

== matlab function VSM_model_v3_GFMs_Synch/GFM 2/VSM Control/Subsystem/freq and theta synch/MATLAB Function2 ==
function y = fcn(u, sync)
% u: Input from the PI controller
% sync: Synchronization ON (1) or OFF (0) signal

% 1. Declare a persistent variable to store the last output when sync was ON.
persistent last_u_value;

% Initialize the persistent variable on the first call
if isempty(last_u_value)
    last_u_value = single(0);
end

on = single(sync);

if on == 1
    % 2. Mode: Pre-synchronization ON (Relay is Open)
    % The output tracks the PI controller output (u) and saves it.
    out = single(u);
    last_u_value = out; % Continuously update the value to be held
else
    % 3. Mode: Pre-synchronization OFF (Relay is Closed)
    % The output is the last value saved when sync was ON.
    % The PI controller's input should already be zero as per your design.
    out = last_u_value; 
end

y = out;

end

== matlab function VSM_model_v3_GFMs_Synch/MATLAB Function ==
function y = fcn(t)

if t>=50.02
    y = 1;
else
    y=0;
end

== matlab function VSM_model_v3_GFMs_Synch/MATLAB Function1 ==
function y = fcn(t)

if t>=64
    y = 1;
else
    y=0;
end

== matlab function VSM_model_v3_GFMs_Synch/Subsystem2/DER 1/MATLAB Function ==
function Idref = calc_Idref(P, V)
    % CALCULATE_IDREF Calculates the d-axis current reference.
    % 
    % Inputs:
    %   P       - Active Power command in Watts (W)
    %   VLL_rms - Line-to-Line RMS Voltage in Volts (V)
    %
    % Output:
    %   Idref   - d-axis current reference in Amperes (A, peak)
    %
    % Note: This assumes a PLL perfectly aligned with the grid voltage (Vq = 0)
    % and uses the amplitude-invariant Clarke/Park transformation.

    % 1. Calculate peak phase voltage (Vd)
    % V_phase_rms = VLL_rms / sqrt(3)
    % V_phase_peak = V_phase_rms * sqrt(2)
    Vd = V * sqrt(2) / sqrt(3); 
    
    % 2. Calculate Idref using the 3-phase amplitude-invariant power equation:
    % P = (3/2) * (Vd * Id + Vq * Iq)
    % Since Vq = 0: P = (3/2) * Vd * Id 
    % Therefore: Id = (2 * P) / (3 * Vd)
    
    Idref = (2 * P) / (3 * Vd);
    
end

== matlab function VSM_model_v3_GFMs_Synch/Subsystem2/DER 1/Boost/MATLAB Function1 ==
function Uref = PandO(Uk1,Ik1)
%参数初始化
%参数初始化
Urefmax=375;
Urefmin=0;
Urefinit=292;
%步长
deltaU=0.4;
persistent Uk0 Pk0 U;
if isempty(Uk0)
    Uk0=0;
    Pk0=0;
    U=Urefinit;
end
%扰动观察法
Pk1=Uk1*Ik1;
dP=Pk1-Pk0;
dU=Uk1-Uk0;
if dP~=0
    if dP>0
        if dU>0
            Uref=U+deltaU;
        else
            Uref=U-deltaU;
        end
    else
        if dU>0
            Uref=U-deltaU;
        else
            Uref=U+deltaU;
        end
    end
else
    Uref=U;
end
if Uref>=Urefmax||Uref<=Urefmin
Uref=U;
end
U=Uref;
Uk0=Uk1;
Pk0=Pk1;

== matlab function VSM_model_v3_GFMs_Synch/Subsystem2/DER 1/Boost/MATLAB Function2 ==
function Uref = INC(Uk1,Ik1)
%参数初始化
Urefmax=375;
Urefmin=0;
Urefinit=292;
%步长
deltaU=0.4;
persistent Uk0 Ik0 U;
if isempty(Uk0)
    Uk0=0;
    Ik0=0;
    U=Urefinit;
end
%电导增量法
dI=Ik1-Ik0;
dU=Uk1-Uk0;
if dU==0
    if dI==0
        Uref=U;
    else
        if dI>0
            Uref=U+deltaU;
        else
            Uref=U-deltaU;
        end

    end


   else
        if (dI/dU==-Ik1/Uk1)
            Uref=U;
        else
            if(dI/dU>-Ik1/Uk1)
             Uref=U+deltaU;
            else
                Uref=U-deltaU;
            end
        end

end
    if Uref>=Urefmax||Uref<=Urefmin
        Uref=U;
    end
    U=Uref;
    Uk0=Uk1;
    Ik0=Ik1;

== matlab function VSM_model_v3_GFMs_Synch/Subsystem2/DER 1/Boost1/MATLAB Function1 ==
function Uref = PandO(Uk1,Ik1)
%参数初始化
%参数初始化
% Urefmax=375; % 10 x 37.5
% Urefmin=0;
% Urefinit=292; % 10 x 29.2

Urefmax=37.5*35; 
Urefmin=0;
Urefinit=29.2*35; 
%步长
deltaU=0.4;
persistent Uk0 Pk0 U;
if isempty(Uk0)
    Uk0=0;
    Pk0=0;
    U=Urefinit;
end
%扰动观察法
Pk1=Uk1*Ik1;
dP=Pk1-Pk0;
dU=Uk1-Uk0;
if dP~=0
    if dP>0
        if dU>0
            Uref=U+deltaU;
        else
            Uref=U-deltaU;
        end
    else
        if dU>0
            Uref=U-deltaU;
        else
            Uref=U+deltaU;
        end
    end
else
    Uref=U;
end
if Uref>=Urefmax||Uref<=Urefmin
Uref=U;
end
U=Uref;
Uk0=Uk1;
Pk0=Pk1;

== matlab function VSM_model_v3_GFMs_Synch/Subsystem2/DER 1/Boost1/MATLAB Function2 ==
function Uref = INC(Uk1,Ik1)
%参数初始化
Urefmax=375;
Urefmin=0;
Urefinit=292;
%步长
deltaU=0.4;
persistent Uk0 Ik0 U;
if isempty(Uk0)
    Uk0=0;
    Ik0=0;
    U=Urefinit;
end
%电导增量法
dI=Ik1-Ik0;
dU=Uk1-Uk0;
if dU==0
    if dI==0
        Uref=U;
    else
        if dI>0
            Uref=U+deltaU;
        else
            Uref=U-deltaU;
        end

    end


   else
        if (dI/dU==-Ik1/Uk1)
            Uref=U;
        else
            if(dI/dU>-Ik1/Uk1)
             Uref=U+deltaU;
            else
                Uref=U-deltaU;
            end
        end

end
    if Uref>=Urefmax||Uref<=Urefmin
        Uref=U;
    end
    U=Uref;
    Uk0=Uk1;
    Ik0=Ik1;

== matlab function VSM_model_v3_GFMs_Synch/GFM 1/VSM Control/MATLAB Function1 ==
function e = EMF(M_fi_f,theta,w)
e=w*M_fi_f*[sin(theta) sin(theta-(2*pi/3)) sin(theta-(4*pi/3))]';
end

== matlab function VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem8/DER/Subsystem1/Subsystem2/MATLAB Function ==
function [id_ref, iq_ref] = calculate_current_refs(P_ref_MW, Q_ref_MVAr, v_d, v_q)
    % Convert inputs from MW/MVAr to Watts/VArs
    P_ref = P_ref_MW * 1e6;
    Q_ref = Q_ref_MVAr * 1e6;
    
    % Safeguard to prevent division by zero during faults/voltage dips
    vd_sq_vq_sq = max(v_d^2 + v_q^2, 1e-6);
    
    % General calculation (works even if PLL is slightly misaligned, v_q ~= 0)
    id_ref = (2/3) * (P_ref * v_d + Q_ref * v_q) / vd_sq_vq_sq;
    iq_ref = (2/3) * (P_ref * v_q - Q_ref * v_d) / vd_sq_vq_sq;
    
    % If PLL is perfectly aligned (v_q = 0), this mathematically reduces to:
    % id_ref = (2/3) * (P_ref / v_d)
    % iq_ref = -(2/3) * (Q_ref / v_d)
end

== matlab function VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem1/DER/Subsystem1/Subsystem2/DSOGI-PLL/Embedded
MATLAB Function27 ==
function [Vds,Vqs]= park(alpha,beta,As)
Vds=alpha*cos(As)+beta*sin(As);
Vqs=-alpha*sin(As)+beta*cos(As);
end

== matlab function VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem8/DER/Subsystem1/Subsystem2/MATLAB Function1 ==
function Q_ref_MVAr = v_var_droop(ud,uq)
% Volt-VAR Droop Controller Parameters (AEMO Compliant)
% The 0.93 Power Factor Rule
% Under NER S5.2.5.1, the Automatic Access Standard requires large generators to be capable of supplying or absorbing reactive power equal to 39.5% of their rated active power.

Pgen_MW_gfl = 20;                       % Target active power: 20 MW
ps_gfl = Pgen_MW_gfl;
V_mag = sqrt(ud^2 + uq^2); % measured
Q_max_MVAr = ps_gfl*0.395;                   % Maximum legal injection (0.93 PF)  39
Q_min_MVAr = -ps_gfl*0.395;  
V_m_gfl=326.6; % Maximum legal absorption (0.93 PF)

V_target_pu = 1.0;                      % Target grid voltage (1.0 pu)
droop_percent = 0.04;                   % 4% Voltage Droop setting

% Calculate the droop gain (Slope of the Volt-VAR curve)
K_q_droop = Q_max_MVAr / droop_percent;  % 197.5 MVAr per 1.0 pu voltage error

    % 1. Convert measured raw voltage to per-unit (pu)
    % V_base_peak is your 326.6 V phase-to-neutral peak base
    V_measured_pu = V_mag/ V_m_gfl;
    
    % 2. Calculate the voltage error
    V_error_pu = V_target_pu - V_measured_pu;
    
    % 3. Apply the Droop Gain to calculate requested Reactive Power
    Q_requested = V_error_pu * K_q_droop;
    
    % 4. Enforce the AEMO Hardware Limits (Saturation)
    if Q_requested > Q_max_MVAr
        Q_ref_MVAr = Q_max_MVAr;
    elseif Q_requested < Q_min_MVAr
        Q_ref_MVAr = Q_min_MVAr;
    else
        Q_ref_MVAr = Q_requested;
    end
    
end

== matlab function VSM_model_v3_GFMs_Synch/Subsystem7/Subsystem1/DER/Subsystem1/Subsystem2/DSOGI-PLL/Embedded
MATLAB Function7 ==
function Am = mod(A)
Am= mod(A,2*pi);
end
